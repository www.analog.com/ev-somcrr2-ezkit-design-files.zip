# Allegro board 08_081712c.brd (continued)
## Nets (continued)
UNNAMED_4_ADLT8609_I14_PG: R452.1 U4.8
UNNAMED_4_ADLT8609_I14_RT: R448.1 U4.4
UNNAMED_4_ADLT8609_I14_SW: C312.1 L7.2(N2) U4.2
UNNAMED_4_ADLT8609_I14_TR: C314.1 U4.7
UNNAMED_4_ADLT8609_I48_BST: C311.2(N2) U3.1
UNNAMED_4_ADLT8609_I48_FB: C315.1 R453.1 R455.1 U3.6
UNNAMED_4_ADLT8609_I48_INTVCC: C309.1 U3.3
UNNAMED_4_ADLT8609_I48_PG: R451.1 U3.8
UNNAMED_4_ADLT8609_I48_RT: R447.1 U3.4
UNNAMED_4_ADLT8609_I48_SW: C311.1 L6.2(N2) U3.2
UNNAMED_4_ADLT8609_I48_TR: C313.1 U3.7
UNNAMED_4_ADLT8609_I60_BST: C299.2(N2) U50.1
UNNAMED_4_ADLT8609_I60_FB: C303.1 R443.1 R445.1 U50.6
UNNAMED_4_ADLT8609_I60_INTVCC: C296.1 U50.3
UNNAMED_4_ADLT8609_I60_PG: R441.1 U50.8
UNNAMED_4_ADLT8609_I60_RT: R439.1 U50.4
UNNAMED_4_ADLT8609_I60_SW: C299.1 L5.2(N2) U50.2
UNNAMED_4_ADLT8609_I60_TR: C300.1 U50.7
UNNAMED_4_CAP_I21_N2: C298.2(N2) F1.1 P7.1
UNNAMED_4_CHOKE4P_I25_N3: D10.A(P) L2.2(N2)
UNNAMED_4_CHOKE4P_I25_N4: C415.2(N2) D9.C F1.2(N2) L2.1
UNNAMED_11_CAP_I4_N1: C1.1 R9.2(N2) R13.2(N2) U5.1
UNNAMED_11_CAP_I12_N1: C2.1 R10.2(N2) R14.2(N2) U5.3
UNNAMED_11_CMOSNC7SP14_I15_Y: R17.1 U5.6
UNNAMED_11_CMOSNC7SP14_I16_Y: R18.1 U5.4
UNNAMED_11_ICTC7MBL3126_I146_A1: R17.2(N2) U7.2
UNNAMED_11_ICTC7MBL3126_I146_A2: R18.2(N2) U7.5
UNNAMED_11_RES_I11_N1: PB2.3 R10.1
UNNAMED_12_ADLT8618_I115_BST: C351.1 U55.1
UNNAMED_12_ADLT8618_I115_INTVCC: C344.1 U55.4
UNNAMED_12_ADLT8618_I115_PG: R486.2(N2) U55.8
UNNAMED_12_ADLT8618_I115_RT: R483.1 U55.5
UNNAMED_12_ADLT8618_I115_SW: C351.2(N2) L8.1 U55.2
UNNAMED_12_ADLT8618_I115_TR: C347.1 U55.7
UNNAMED_12_CAP_I55_N1: C327.1 E4.1 U54.D8
UNNAMED_12_CAP_I60_N1: C329.1 E5.1 U54.C4
UNNAMED_12_CN2P_I21_N1: P28.1 U54.J10
UNNAMED_12_CN2P_I28_N2: P29.2(N2) R473.1 U54.M9
UNNAMED_12_CN24PAB2GND6SHLD_I15: P9.A5 R479.1
UNNAMED_12_CN24PAB2GND6SHLD_I_1: P9.B5 R480.1
UNNAMED_12_DIOLED4PV32_I159_CB: D12.3 R478.2(N2)
UNNAMED_12_DIOLED4PV32_I159_CG: D12.1 R476.2(N2)
UNNAMED_12_DIOLED4PV32_I159_CR: D12.2(C_R) R477.2(N2)
UNNAMED_12_DIOLED_I141_N: DS20.C R487.1
UNNAMED_12_FERRITE_I19_N2: E3.2(N2) U54.E1(VREFP)
UNNAMED_12_ICATSAMXXXQ21XCFX__1: R472.2(N2) U54.L12
UNNAMED_12_ICATSAMXXXQ21XCFX_I1: R474.1 U54.N9
UNNAMED_13_74245V6_I21_1B1: R492.1 U58.13
UNNAMED_13_74245V6_I21_1B2: R494.1 U58.12
UNNAMED_13_74245V6_I21_2B1: R493.1 U58.11
UNNAMED_13_74245V6_I21_2B2: R495.1 U58.10
UNNAMED_13_74245V6_I68_1A1: R501.2(N2) U60.4
UNNAMED_13_74245V6_I68_1A2: R499.2(N2) U60.5
UNNAMED_13_74245V6_I68_2A1: R500.2(N2) U60.6
UNNAMED_13_RES_I32_N1: R489.1 S11.16
UNNAMED_14_DIOLED_I1_N: DS7.C R420.1
UNNAMED_14_DIOLED_I5_N: DS9.C R422.1
UNNAMED_14_DIOLED_I7_N: DS8.C R421.1
UNNAMED_14_DIOLED_I53_N: DS12.C R425.1
UNNAMED_14_DIOLED_I54_N: DS11.C R424.1
UNNAMED_14_DIOLED_I57_N: DS10.C R423.1
USB_5V: C336.1 C339.1 C341.1 C343.1 P9.A4 P9.A9 P9.B4 P9.B9(N9) R481.1 TP23.1(N1) U55.9 U55.10(VIN)
USBI_SCL: P30.3 S12.1B S12.4B S12.7B
USBI_SCL_B: P31.3 S13.1B S13.4B S13.7B
USBI_SDA: P30.5 S12.2B S12.5B S12.8B(N9)
USBI_SDA_B: P31.5 S13.2B S13.5B S13.8B(N9)
XIN: C333.1 U54.A2 Y6.1
XIN32: C335.1 U54.N1 Y5.1
XOUT: C342.1 U54.B2 Y6.3(N2)
XOUT32: C338.1 U54.N2 Y5.2(N2)
XSPI_CLK_SOM_A: R34.1 R38.1 SOMA.26 TP2.1(N1)
XSPI_CLK_SOM_A*: R36.1 R40.1 SOMA.24 TP4.1(N1)
XSPI_CS1_SOM_A*: R33.2(N2) R37.1 SOMA.20 TP1.1(N1)
XSPI_CS2_SOM_A*: R35.2(N2) R39.1 SOMA.22 TP3.1(N1)
XSPI_DQ0_SOM_A: R42.2(N2) SOMA.4 TP10.1(N1)
XSPI_DQ1_SOM_A: R46.2(N2) SOMA.6 TP12.1(N1)
XSPI_DQ2_SOM_A: R47.2(N2) SOMA.8 TP8.1(N1)
XSPI_DQ3_SOM_A: R43.2(N2) SOMA.10 TP6.1(N1)
XSPI_DQ4_SOM_A: R44.2(N2) SOMA.12 TP11.1(N1)
XSPI_DQ5_SOM_A: R48.2(N2) SOMA.14 TP13.1(N1)
XSPI_DQ6_SOM_A: R45.2(N2) SOMA.16 TP7.1(N1)
XSPI_DQ7_SOM_A: R49.2(N2) SOMA.18 TP9.1(N1)
XSPI_RWDS_SOM_A*: R41.2(N2) R50.2(N2) R51.1 SOMA.2 TP5.1(N1)

Pads without a net: D1 5; D2 5; D3 5; D4 5; D13 4 5; J4 3 7 11 15 19 23 27 31 35 39 43 47 51 55 59 83 85 87 96 98 100; J5 3 7 11 15 19 23 27 31 35 39 43 47 51 55 59 83 85 87 96 98 100; P1 15 16; P2 15 16; P3 3 7 11 15 19 23 27 31 35 39 43 47 51 55 59 83 85 87 96 98 100; P4 3 7 11 15 19 23 27 31 35 39 43 47 51 55 59 83 85 87 96 98 100; P8 3 5 7; P9 A2 A3 A8 A10 A11 B2 B3 B8 B10 B11; P14 13A 13B; P16 13; P18 1_1 1_4 1_8 2_1 2_4 2_8; P19 1_1 1_4 1_8 2_1 2_4 2_8; P22 3; P23 3; P24 3; P25 3; P26 3; P27 3; P30 1 2 4 13 14 16; P31 1 2 4 13 14 16; P34 7 9; P35 7 9 11 13; PB1 4; PB2 4; PB3 4; PB4 4; S11 9; S12 3A 3B 6A 6B; S13 3A 3B 6A 6B; S14 1 4 5; SOMA 117 119 135 137 139 141 143 147 149 151 153 155 159 161 163 165 167 171 173 175 177 179 183 185 187 189 195 197 199 201 205 207 209 211 215 217 218 219 220 221 222 224 226 228 230 232 234 236 237 239 240 241 242 243 244 245 246 247 248 249 250 252 254 256 258 270 276; SOMB 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 117 119 135 137 139 141 143 147 149 151 153 155 159 161 163 165 167 171 173 175 177 179 183 185 187 189 195 197 199 201 205 207 209 211 215 217 218 219 220 221 222 224 226 228 230 232 234 236 237 239 240 241 242 243 244 245 246 247 248 249 250 252 254 256 258 270 276; U1 6 8; U2 6 8; U3 5; U4 5; U8 24; U11 1 5; U12 1 5; U18 8 23 24 25 26 27 30; U19 8 23 24 25 26 27 30; U33 18 31 32; U41 7 15; U42 7 15; U43 7 15; U44 7 15; U49 5; U50 5; U51 9 10 11 12 13 24; U54 A1 A6 A7 A8 A9 A10 A11 A12 A13 B1 B6 B7 B8 B9 B10 B11 B12 B13 C2 C8 C9 C10 C11 D1 D2 D11 D12 E10 E11 E12 F1 F3 F11 F12 F13 G2 G4 G12 H2 H3 H4 H11 H12 J1 J2 J3 J12 J13 K1 K2 K3 K7 K10 K13 L1 L2 L3 L4 L5 L7 L8 L10 L11 L13 M1 M2 M3 M5 M7 M8 M10 M11 M12 M13 N3 N5 N6 N7 N8 N12 N13; U65 A5 B5 C5; U70 3 4 6; U72 3 4 6; U77 5; U78 5

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 6380 vias
v2: diameter 0.203, hole 0.102, TOP to BOTTOM, 54 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0V9: length 15.5
  L6_PWR w0.508: TP14.1 218.48,67.63 ; TP14.1 217.04,69.06 ; TP14.1 215.61,67.63 ; TP14.1 217.04,66.19
  BOTTOM w0.203: U1.4 139.9,44.19 140.14,43.94 ; U1.28 v1(132.97,44.69) ; U1.36 v1(136.77,46.99)
  BOTTOM w0.457: v1(140.97,43.94) v1(140.46,43.94) 140.14,43.94
  BOTTOM w0.508: v1(136.77,46.99) v1(136.77,47.5) ; TP14.1 218.48,67.63 ; TP14.1 215.61,67.63 ; TP14.1 217.04,69.06 ; TP14.1 217.04,66.19 ; v1(132.97,44.69) v1(132.46,44.69)
  vias: v1(145.2,44.01) v1(145.96,44.01) v1(146.72,44.01) v1(147.49,44.01) v1(218.31,70.36) v1(218.31,69.85) v1(218.82,70.36) v1(218.82,69.85)
0V9_B: length 15.5
  L6_PWR w0.508: 221.61,66.19 TP15.1 ; TP15.1 223.05,67.63 ; TP15.1 220.18,67.63 ; TP15.1 221.61,69.06
  BOTTOM w0.203: 267.14,43.94 266.9,44.19 U2.4 ; U2.36 v1(263.77,46.99) ; U2.28 v1(259.97,44.69)
  BOTTOM w0.457: v1(267.97,43.94) v1(267.46,43.94) 267.14,43.94
  BOTTOM w0.508: 220.18,67.63 TP15.1 ; TP15.1 221.61,66.19 ; TP15.1 221.61,69.06 ; TP15.1 223.05,67.63 ; v1(263.77,46.99) v1(263.77,47.5) ; v1(259.97,44.69) v1(259.46,44.69)
  vias: v1(219.84,70.36) v1(219.84,69.85) v1(220.34,70.36) v1(220.34,69.85) v1(272.2,44.01) v1(272.96,44.01) v1(273.72,44.01) v1(274.49,44.01)
3V3: length 228.5
  TOP w0.14: C431.1 v1(188.33,87.93)
  TOP w0.305: U33.12 99.1,120.69 98.93,120.52 98.42,120.52 ; U19.12 221.52,117.64 C94.1 ; C192.1 117.91,126.54 U33.58 ; U19.31 225.52,125.43 C98.1 ; U33.25 104.5,112.37 C197.1 ; 101.35,112.52 102.11,112.52 102.55,112.97 U33.22 ; C107.1 303.24,125.43 U18.31 ; U19.40 221.02,125.43 C102.1 ; U18.40 298.74,125.43 C101.1 ; C194.1 98.24,126.54 U33.3 ; U33.39 113.6,112.59 C195.1 ; C105.1 299.24,117.64 U18.12 ; C196.1 118.58,120.69 U33.49 ; 296.6,122.67 296.85,122.43 298.03,122.43 U18.4 ; 218.88,122.67 219.13,122.43 220.31,122.43 U19.4
  TOP w0.508: R129.1 v1(310.13,116.34) ; C190.1 v1(120.47,128.27) ; v1(294.12,121.95) C83.1 294.16,122.69 C87.1 295.16,122.67 C85.1 296.6,122.67 ; 218.88,122.67 C106.1 217.44,122.67 C88.1 216.43,122.69 C84.1 v1(216.4,121.95) ; U72.8 403.1,27.24 402.59,26.73 C398.1 v1(400.74,26.73) ; C101.1 v1(298.19,126.77) ; TP20.1 387.98,138.43 ; TP20.1 386.21,138.43 ; TP20.1 387.98,136.65 ; TP20.1 386.21,136.65 ; R267.1 v1(31.19,20.37) ; C97.1 v1(299.46,113.18) ; v1(30.61,21.84) C385.1 29.47,22.66 29.14,22.34 U71.5 ; C193.1 v1(95.68,128.27) ; C77.1 v1(305.81,113.06) ; v1(269.46,42.69) 269.46,47.22 270.72,48.47 272.17,48.47 272.29,48.6 C56.1 ; C172.1 v1(112.96,105.67) ; C192.1 v1(117.99,127.33) ; C107.1 303.79,127.27 C89.1 v1(304.03,128.82) ; R128.1 v1(231.27,116.34) ; 98.42,120.52 C198.1 v1(96.52,120.52) ; v1(185.93,126.72) C76.1 184.47,127.59 Y3.4 Y3.1 ; v1(298.95,115.62) C93.1 C105.1 ; C374.1 v1(16.39,20.55) ; U73.5 396.81,22.34 397.14,22.66 C393.1 v1(398.27,21.84) ; v1(33.07,26.73) C387.1 34.92,26.73 35.43,27.24 U70.8 ; R568.1 v1(398.86,20.37) ; C194.1 v1(98.16,127.33) ; R130.1 v1(232.41,116.34) ; v1(142.46,42.69) 142.46,47.22 143.72,48.47 145.17,48.47 145.29,48.6 C30.1 ; R140.2 227.98,113.16 v1(228.08,113.06) C78.1 ; R273.1 v1(127.11,107.16) ; R271.1 v1(124.47,107.16) ; C197.1 v1(104.27,111.35) 104.65,110.98 R284.1 ; 101.35,112.52 100.33,112.52 98.93,111.12 98.93,109.98 99.43,109.48 C178.1 v1(100.08,108.81) Q1.3 ; C108.1 v1(221.73,113.18) ; R138.2 v1(226.83,113.41) ; C380.1 v1(384.06,20.55) ; C94.1 C86.1 v1(221.23,115.62) ; C196.1 v1(120.02,120.65) ; R269.1 v1(128.89,107.16) ; C195.1 v1(113.93,111.56) ; C102.1 v1(220.46,126.77) ; R132.2 v1(230.12,116.34) ; C173.1 v1(124.2,105.67) ; v1(226.3,128.82) C90.1 226.07,127.27 C98.1 ; R131.2 v1(307.85,116.34) ; R127.1 v1(308.99,116.34)
  L3_SIG w0.127: v1(219.32,76.8) 218.86,76.8 216.66,78.99 v1(216.66,81.53)
  L6_PWR w0.508: 268.5,26.38 P2.20 ; P2.20 269.62,25.26 ; P2.20 270.74,26.38 ; M1.1 12.55,10.9 ; M1.1 10.31,10.9 ; M1.1 11.43,9.78 ; M1.1 11.43,12.01 ; M1.5 15.09,15.9 ; M1.5 12.85,15.9 ; M1.5 13.97,17.01 ; M1.5 13.97,14.78 ; 381.63,14.78 M2.5 ; M2.5 380.52,15.9 ; M2.5 381.63,17.01 ; M2.5 382.75,15.9 ; 379.1,9.78 M2.1 ; M2.1 377.98,10.9 ; M2.1 379.1,12.01 ; M2.1 380.21,10.9 ; P1.20 143.74,26.38 ; P1.20 141.5,26.38 ; P1.20 142.62,25.26 ; TP20.1 387.98,138.43 ; TP20.1 386.21,136.65 ; TP20.1 386.21,138.43 ; TP20.1 387.98,136.65
  BOTTOM w0.14: C429.1 v1(188.33,79.35)
  BOTTOM w0.203: 260.99,40.01 261.28,40.3 U2.20 ; U2.11 265.77,40.3 266.06,40.01 ; U1.11 138.77,40.3 139.06,40.01 ; U1.20 134.28,40.3 133.98,40.01
  BOTTOM w0.254: TP20.1 395.48,137.54 402.59,130.43 v1(406.4,130.43)
  BOTTOM w0.305: U13.6 v1(219.32,76.8)
  BOTTOM w0.508: R362.1 v1(67.66,8.13) ; C177.1 100.08,107.76 v1(100.08,108.81) ; R371.1 v1(330.58,14.83) ; v1(104.27,111.35) 104.27,112.2 C189.1 ; v1(120.02,120.65) 119.06,120.65 C185.1 ; v1(113.93,111.56) 113.93,112.2 C184.1 ; v1(139.7,36.83) 139.33,37.21 v1(139.33,37.22) C390.1 C27.1 139.33,39.75 139.06,40.01 ; v1(260.35,36.83) 260.72,37.21 v1(260.72,37.22) C49.1 C53.1 260.72,39.75 260.99,40.01 ; v1(381.66,18.9) C378.1 382.4,16.67 M2.5 ; 133.98,40.01 133.72,39.75 C25.1 C21.1 v1(133.72,37.22) 133.72,37.21 v1(133.35,36.83) ; C171.1 v1(120.59,105.67) ; v1(148.58,38.73) C17.1 146.46,38.73 Y1.1 Y1.4 ; M2.1 379.86,11.67 C379.1 ; v1(266.7,36.83) 266.33,37.21 v1(266.33,37.22) C47.1 C51.1 266.33,39.75 266.06,40.01 ; M1.5 14.74,16.67 C373.1 v1(13.99,18.9) ; v1(275.58,38.73) C43.1 273.46,38.73 Y2.1 Y2.4 ; v1(96.52,120.52) 97.34,120.52 C187.1 ; v1(216.66,81.53) 216.98,81.85 C69.1 ; C375.1 12.2,11.67 M1.1 ; R79.2 v1(127.88,39.37) ; R100.1 v1(269.46,42.69) ; R363.1 v1(67.66,14.86) ; R111.2 v1(254.88,39.37) ; R370.1 v1(330.58,8.1) ; R68.1 v1(142.46,42.69)
  vias: v1(145.14,49.74) v1(145.9,49.74) v1(146.66,49.74) v1(147.43,49.74) v1(182.33,124.69) v1(216.15,82.04) v1(216.15,81.53) v1(216.66,82.04) v1(272.14,49.74) v1(272.9,49.74) v1(273.66,49.74) v1(274.43,49.74) v1(384.81,137.8) v1(384.81,137.16) v1(385.44,137.8) v1(385.44,137.16)
5V: length 68.7
  TOP w0.508: R223.1 v1(229.04,154.37) ; v1(90.54,22.53) C276.1 C274.1 90.54,25.76 90.55,25.77 U41.14 ; A2.5 207.07,123 C110.1 v1(206.22,122.94) ; v1(353.46,22.5) C287.1 C285.1 353.46,25.73 353.47,25.74 U43.14 ; R251.1 v1(189.42,154.37) ; R167.1 v1(306.77,154.37) ; R214.1 v1(257.11,154.37) ; R245.1 v1(208.47,154.37) ; R217.1 v1(248.09,154.37) ; R189.1 v1(286.19,154.37) ; v1(283.95,122.94) C109.1 284.79,123 A1.5 ; v1(339.36,22.5) C286.1 C284.1 339.36,25.73 339.37,25.74 U44.14 ; TP21.1 387.1,181.9 ; TP21.1 385.91,180.72 ; TP21.1 388.28,180.72 ; R158.1 v1(334.84,154.37) ; v1(76.45,22.53) C277.1 C275.1 76.45,25.76 76.45,25.77 U42.14 ; R164.1 v1(315.79,154.37) ; R242.1 v1(217.49,154.37) ; R195.1 v1(267.14,154.37) ; R161.1 v1(325.82,154.37) ; R186.1 v1(295.21,154.37) ; R192.1 v1(276.16,154.37) ; R220.1 v1(238.06,154.37) ; R248.1 v1(198.44,154.37)
  L6_PWR w0.508: 387.1,179.54 TP21.1 ; TP21.1 387.1,181.9 ; TP21.1 385.91,180.72 ; TP21.1 388.28,180.72
  BOTTOM w0.254: TP21.1 395.48,180.72 402.59,173.61 v1(406.4,173.61)
  vias: v1(384.81,180.98) v1(384.81,180.34) v1(385.44,180.98) v1(385.44,180.34)
5V_SOM_A: length 18.7
  TOP w0.508: 101.18,76.33 TP30.1 ; TP30.1 102.36,75.15 ; TP30.1 103.54,76.33 ; SOMA.E1 104.97,66.24 104.27,65.53 104.27,63.37 99.82,58.93 v1(95.5,58.93)
  vias: v1(107.19,71.63) v1(107.19,70.99) v1(107.82,71.63) v1(107.82,70.99) v1(108.46,71.63) v1(108.46,70.99)
5V_SOM_B: length 23.4
  TOP w0.127: SOMB.E2 233.64,70.92 ; 234.17,68.12 234.11,68.12 233.4,67.41 SOMB.E1
  TOP w0.508: TP31.1 230.54,76.33 ; TP31.1 228.18,76.33 ; TP31.1 229.36,75.15 ; v1(222.5,58.93) 226.57,58.93 231.27,63.63 231.27,65.53 231.97,66.24 SOMB.E1
  vias: v1(234.19,71.25) v1(234.19,70.61) v1(234.82,71.25) v1(234.82,70.61) v1(235.46,71.25) v1(235.46,70.61)
10V: length 56
  TOP w0.508: U27.8 229.48,145.67 C140.1 v1(228.97,144.45) ; TP17.1 387.98,159.39 ; TP17.1 387.98,161.16 ; TP17.1 386.21,159.39 ; TP17.1 386.21,161.16 ; v1(189.35,144.45) C154.1 189.86,145.67 U29.8 ; v1(325.75,144.45) C111.1 326.26,145.67 U22.8 ; U25.8 267.58,145.67 C126.1 v1(267.07,144.45) ; U23.8 307.21,145.67 C112.1 v1(306.7,144.45) ; v1(286.12,144.45) C125.1 286.63,145.67 U24.8 ; U28.8 208.91,145.67 C153.1 v1(208.4,144.45) ; U26.8 248.53,145.67 C139.1 v1(248.02,144.45)
  L5_PWR w0.508: TP17.1 387.98,159.39 ; TP17.1 386.21,161.16 ; TP17.1 386.21,159.39 ; TP17.1 387.98,161.16
  BOTTOM w0.254: v1(406.4,153.16) 402.59,153.16 395.48,160.27 TP17.1
  vias: v1(384.81,160.53) v1(384.81,159.89) v1(385.44,160.53) v1(385.44,159.89)
12V: length 47.2
  TOP w0.305: R460.2 v1(367.88,173.99)
  TOP w0.508: TP18.1 407.79,110.61 ; TP18.1 407.79,108.84 ; TP18.1 406.02,108.84 ; TP18.1 406.02,110.61 ; TP22.1 407.79,133.47 ; TP22.1 406.02,133.47 ; TP22.1 407.79,131.7 ; TP22.1 406.02,131.7 ; TP19.1 407.79,156.21 ; TP19.1 406.02,154.43 ; TP19.1 407.79,154.43 ; TP19.1 406.02,156.21
  L5_PWR w0.508: 406.02,156.21 TP19.1 ; TP19.1 406.02,154.43 ; TP19.1 407.79,154.43 ; TP19.1 407.79,156.21 ; 406.02,133.47 TP22.1 ; TP22.1 407.79,131.7 ; TP22.1 406.02,131.7 ; TP22.1 407.79,133.47 ; TP18.1 407.79,110.61 ; TP18.1 406.02,108.84 ; TP18.1 406.02,110.61 ; TP18.1 407.79,108.84
  BOTTOM w0.127: J4.95 v1(9.33,78.16) ; J4.97 v1(8.7,78.48) ; J5.97 v1(61.4,78.48) ; J5.95 v1(62.04,78.16) ; J5.99 v1(60.77,78.16) ; J4.99 v1(8.06,78.16)
  BOTTOM w0.254: P4.97 v1(376.75,78.48) ; P3.99 v1(323.41,78.16) ; P3.97 v1(324.04,78.48) ; P3.95 v1(324.68,78.16) ; P4.95 v1(377.38,78.16) ; P4.99 v1(376.11,78.16)
  vias: v1(96.39,60.71) v1(96.39,60.07) v1(97.03,60.71) v1(97.03,60.07) v1(223.39,60.71) v1(223.39,60.07) v1(224.03,60.71) v1(224.03,60.07) v1(372.62,180.85) v1(372.62,179.96) v1(373.51,180.85) v1(373.51,179.96) v1(374.4,180.85) v1(374.4,179.96) v1(404.88,175.39) v1(404.88,174.75) v1(404.88,154.94) v1(404.88,154.31) v1(404.88,132.21) v1(404.88,131.57) v1(404.88,109.35) v1(404.88,108.71) v1(405.51,175.39) v1(405.51,174.75) v1(405.51,154.94) v1(405.51,154.31) v1(405.51,132.21) v1(405.51,131.57) v1(405.51,109.35) v1(405.51,108.71)
DGND: length 8638.6
  TOP w0.127: SOMB.169 v1(283.14,64.78) ; SOMA.181 v1(159.14,64.78) ; SOMA.121 v1(144.14,64.78) ; SOMA.235 v1(172.65,64.78) ; SOMA.262 v1(179.4,75.45) ; SOMA.160 v1(153.9,75.45) ; SOMA.145 v1(150.14,64.78) ; SOMB.272 v1(308.89,74.95) ; v1(257.43,77.72) 258.9,76.26 SOMB.72 ; SOMA.265 v1(180.14,64.27) ; SOMA.191 v1(161.65,64.78) ; SOMB.191 v1(288.65,64.78) ; SOMB.SH2 v1(315.14,73.77) ; v1(130.4,77.09) 130.94,77.09 131.9,76.13 SOMA.72 ; SOMB.27 v1(247.64,64.78) ; SOMB.238 v1(300.39,74.95) ; SOMB.148 v1(277.9,75.45) ; SOMA.85 v1(135.15,64.27) ; SOMB.229 298.14,68.12 298.7,68.68 v1(298.7,69.47) ; SOMA.27 v1(120.64,64.78) ; SOMB.268 v1(307.89,74.95) ; SOMA.203 v1(164.65,64.78) ; SOMA.223 v1(169.65,64.78) ; SOMB.206 v1(292.39,74.95) ; SOMB.180 v1(285.9,75.45) ; SOMB.109 v1(268.15,64.27) ; SOMA.279 v1(183.65,64.78) ; SOMB.71 v1(258.64,64.78) ; SOMB.193 v1(289.14,64.27) ; SOMA.157 v1(153.14,64.78) ; SOMA.148 v1(150.9,75.45) ; SOMB.145 v1(277.14,64.78) ; SOMB.73 v1(259.15,64.27) ; SOMB.281 311.14,68.12 v1(311.44,68.41) ; SOMB.49 v1(253.15,64.27) ; SOMA.193 v1(162.14,64.27) ; SOMA.97 v1(138.15,64.27) ; SOMA.SH1 v1(100.15,73.77) ; SOMA.268 v1(180.89,74.95) ; SOMA.134 v1(147.39,74.95) ; SOMA.174 v1(157.39,74.95) ; SOMA.28 v1(120.9,75.45) ; SOMB.166 v1(282.39,74.95) ; SOMA.166 v1(155.39,74.95) ; SOMA.169 v1(156.14,64.78) ; SOMA.E3 v1(111.4,64.78) ; v1(248.28,78.61) 247.9,78.22 SOMB.28 ; SOMB.154 v1(279.39,74.95) ; SOMA.213 v1(167.14,64.78) ; SOMA.49 v1(126.15,64.27) ; v1(299.65,69.47) SOMB.235 ; SOMB.157 v1(280.14,64.78) ; SOMA.90 136.39,76.24 v1(137.88,77.72) ; SOMB.260 v1(305.89,74.95) ; SOMA.229 v1(171.14,64.27) ; SOMB.121 v1(271.15,64.78) ; SOMB.50 v1(253.39,76.05) ; SOMB.196 v1(289.9,75.45) ; SOMB.134 v1(274.39,74.95) ; SOMB.279 v1(310.65,69.27) ; SOMB.186 v1(287.39,74.95) ; SOMA.238 v1(173.39,74.95) ; SOMB.223 296.65,64.62 295.88,63.85 v1(295.88,61.71) ; SOMA.272 v1(181.89,74.95) ; SOMA.280 v1(183.89,75.45) ; SOMB.262 v1(306.4,75.45) ; SOMA.196 v1(162.9,75.45) ; SOMA.278 v1(183.4,74.95) ; SOMA.50 v1(126.39,74.95) ; SOMA.71 v1(131.64,64.78) ; SOMA.216 v1(167.9,75.45) ; v1(264.88,77.72) 263.39,76.24 SOMB.90 ; SOMA.109 v1(141.15,64.27) ; SOMB.133 v1(274.14,64.78) ; SOMA.206 v1(165.39,74.95) ; SOMB.85 v1(262.15,64.27) ; SOMA.110 v1(141.39,74.95) ; SOMA.154 v1(152.39,74.95) ; SOMA.180 v1(158.9,75.45) ; SOMA.186 v1(160.39,74.95) ; SOMA.281 v1(184.14,64.27) ; SOMB.216 v1(294.9,75.45) ; 303.65,66.24 v1(303.65,69.27) ; SOMB.160 v1(280.9,75.45) ; SOMA.124 v1(144.9,75.45) ; SOMB.110 v1(268.39,74.95) ; SOMB.203 v1(291.65,64.78) ; SOMB.181 v1(286.14,64.78) ; SOMB.97 v1(265.15,64.27) ; SOMA.73 v1(132.15,64.27) ; SOMB.265 v1(307.14,68.76) ; SOMB.278 v1(310.4,74.95) ; SOMB.174 v1(284.39,74.95) ; SOMA.133 v1(147.14,64.78) ; SOMB.213 v1(294.14,64.78) ; SOMA.251 v1(176.65,64.78) ; SOMA.260 v1(178.89,74.95) ; SOMB.280 v1(310.89,75.45) ; SOMB.124 v1(271.9,75.45)
  TOP w0.14: U9.11 v1(211.29,87.38) ; 310.89,72.23 SOMB.280 311.33,73.49 ; 184.14,67.49 SOMA.281 184.58,66.24 ; 184.33,73.49 SOMA.280 183.89,72.23 ; U52.8 v1(233.77,87.02) ; U9.7 v1(202.73,85.43) ; 311.58,66.24 SOMB.281 311.14,64.98 ; C431.2 v1(186.51,87.12) ; U9.12 v1(211.58,88.03) ; U15.8 v1(233.77,79.91) ; U66.1 v1(236.89,26.64) ; U14.8 v1(233.77,94.52) ; C430.2 v1(186.51,85.6)
  TOP w0.203: U59.3 221.28,21.51 221.49,21.3 v1(221.49,20.64) ; U20.6 v1(303.06,111.38) ; U75.7 v1(383.48,28.87) ; U74.7 v1(15.81,28.87) ; U32.6 v1(127.73,103.87) ; 207.29,6 P9.SH5 ; P9.SH5 207.64,5.25 ; P9.SH5 207.64,6.74 ; P9.SH5 208,6 ; v1(379.98,22.65) 380.28,22.35 U68.6 ; U16.6 v1(309.41,111.38) ; v2(207.45,18.91) U54.B5 ; P9.SH6 208,2.9 ; P9.SH6 207.29,2.9 ; P9.SH6 207.64,3.65 ; U21.6 v1(225.34,111.38) ; U63.6 12.61,22.35 v1(12.32,22.65) ; v2(208.24,19.71) U54.D3 ; U17.6 v1(231.69,111.38)
  TOP w0.254: U41.13 89.84,26.47 ; U41.13 89.28,27.72 ; U41.13 88.72,26.47 ; SOMB.109 268.15,67.49 ; 189.48,162.95 R240.2 189.48,164.2 ; U44.13 338.66,26.44 ; U44.13 337.54,26.44 ; U44.13 338.1,27.7 ; P27.1 322.33,111.04 ; P27.1 322.33,108.67 ; P27.1 323.51,109.86 ; P27.1 321.14,109.86 ; 286.25,162.95 R183.2 286.25,164.2 ; 8.34,86.36 P32.9 ; P32.9 9.53,85.18 ; P32.9 10.71,86.36 ; P32.9 9.53,87.54 ; 162.9,72.23 SOMA.196 ; P11.GND3 132.9,180.56 ; P11.GND3 131.14,182.33 ; P11.GND3 131.14,178.8 ; P11.GND3 129.37,180.56 ; 250.28,135.39 R234.2 ; R234.2 249.63,136.14 ; R234.2 250.28,136.89 ; 162.14,103 P5.16 ; P5.16 164.5,103 ; P5.16 163.32,101.82 ; 68.83,118.62 R346.2 69.46,118.05 ; 91.67,148.88 C238.2 ; C238.2 91.67,150.84 ; C238.2 92.5,149.86 ; 47.08,59.31 P20.12 ; P20.12 49.44,59.31 ; P20.12 48.26,60.49 ; P20.12 48.26,58.13 ; 240.78,90.67 R522.2 240.78,89.42 ; 48.26,47.97 P20.16 ; P20.16 47.08,49.15 ; P20.16 48.26,50.33 ; P20.16 49.44,49.15 ; R177.2 332.65,136.89 ; R177.2 332.65,135.39 ; R177.2 333.3,136.14 ; C309.2 393.65,130.05 ; C309.2 392.75,131.1 ; C309.2 392.75,128.99 ; 407.63,19.62 R569.2 ; R569.2 406.98,20.37 ; R569.2 407.63,21.12 ; 285.25,88.32 R30.2 286.5,88.32 ; 236.09,148.92 U27.4 ; U27.4 236.09,150.04 ; U27.4 234.75,149.48 ; P20.20 49.44,38.99 ; P20.20 47.08,38.99 ; P20.20 48.26,37.81 ; P20.20 48.26,40.17 ; P16.8 275.22,179.3 ; P16.8 275.22,177.19 ; P16.8 274.17,178.24 ; P16.8 276.28,178.24 ; 77.78,161.67 R327.2 78.36,161.05 ; 392.75,151.73 C294.2 ; C294.2 392.75,153.84 ; C294.2 393.65,152.78 ; 240.15,99.64 C72.2 240.15,98.48 ; 354.45,37.95 C281.2 ; P40.10 368.21,61.85 ; P40.10 365.85,61.85 ; P40.10 367.03,63.03 ; P40.10 367.03,60.67 ; U41.16 93.09,27.72 ; U41.16 92.53,26.47 ; U41.16 93.65,26.47 ; 58.86,180.77 P14.16B ; P14.16B 57.62,182.02 ; P14.16B 58.86,183.26 ; P14.16B 60.11,182.02 ; 50.51,56.77 P21.8 ; P21.8 52.87,56.77 ; P21.8 51.69,57.95 ; P21.8 51.69,55.59 ; 362.42,69.47 P39.8 ; P39.8 363.6,70.65 ; P39.8 363.6,68.29 ; P39.8 364.78,69.47 ; 276.11,162.95 R182.2 276.11,164.2 ; 99.49,110.48 C178.2 100.66,110.48 ; P14.SH4 92.05,190.91 ; P14.SH4 92.05,186.64 ; P14.SH4 94.18,188.77 ; P14.SH4 89.92,188.77 ; 146.7,111.72 R298.2 147.32,111.15 ; 215.73,34.6 U58.9 ; U58.9 217.12,34.6 ; U58.9 216.42,34.97 ; 304.81,110.03 C91.2 304.81,111.2 ; 321.14,86.36 P33.11 ; P33.11 323.51,86.36 ; P33.11 322.33,85.18 ; P33.11 322.33,87.54 ; 196.25,135.39 R263.2 ; R263.2 196.25,136.89 ; R263.2 196.9,136.14 ; P39.16 363.6,50.33 ; P39.16 362.42,49.15 ; P39.16 363.6,47.97 ; P39.16 364.78,49.15 ; C218.2 109.77,149.86 ; C218.2 108.94,148.88 ; C218.2 108.94,150.84 ; 327.35,136.14 R178.2 ; R178.2 328,136.89 ; R178.2 328,135.39 ; C384.2 37.34,17.27 ; C384.2 38.39,16.37 ; C384.2 36.28,16.37 ; 83.64,26.47 U41.9 ; U41.9 84.76,26.47 ; U41.9 84.2,27.72 ; 71.32,177.93 P14.8B ; P14.8B 71.32,180.42 ; P14.8B 70.08,179.17 ; 265.89,178.24 P16.5 ; P16.5 266.94,177.19 ; P16.5 268,178.24 ; P16.5 266.94,179.3 ; 51.69,70.83 P21.14 ; P21.14 51.69,73.19 ; P21.14 50.51,72.01 ; P21.14 52.87,72.01 ; C200.2 136.49,130.64 ; C200.2 134.53,130.64 ; C200.2 135.51,129.82 ; C234.2 74.4,150.84 ; C234.2 75.23,149.86 ; C234.2 74.4,148.88 ; 194.64,178.8 P13.GND3 ; P13.GND3 196.4,180.56 ; P13.GND3 192.87,180.56 ; P13.GND3 194.64,182.33 ; 208.53,162.95 R239.2 208.53,164.2 ; 239.1,88.52 U52.12 237.75,88.52 ; J2.S 402.46,6.63 ; J2.S 401.09,5.26 ; J2.S 402.46,3.89 ; J2.S 403.84,5.26 ; P5.12 159.42,103 ; P5.12 158.24,101.82 ; P5.12 157.06,103 ; P19.2_6 343.45,16.05 ; P19.2_6 343.45,13.56 ; P19.2_6 344.69,14.81 ; P19.2_6 342.2,14.81 ; 368.31,170.83 R459.1 368.31,172.07 ; 162.89,178.8 P12.GND3 ; P12.GND3 161.12,180.56 ; P12.GND3 164.65,180.56 ; P12.GND3 162.89,182.33 ; 93.33,161.05 R332.2 93.9,161.67 ; 298.46,111.2 C263.2 298.46,110.03 ; 365.85,56.77 P40.8 ; P40.8 367.03,55.59 ; P40.8 368.21,56.77 ; P40.8 367.03,57.95 ; 308.95,135.39 R180.2 ; R180.2 308.3,136.14 ; R180.2 308.95,136.89 ; 254.77,88.47 R457.2 254.77,89.71 ; P9.SH4 203.38,4.61 ; P9.SH4 204.23,3.45 ; P9.SH4 202.52,3.45 ; 150.62,101.82 P5.6 ; P5.6 151.8,103 ; P5.6 149.44,103 ; P11.GND1 132.9,191.86 ; P11.GND1 131.14,190.1 ; P11.GND1 131.14,193.63 ; P11.GND1 129.37,191.86 ; S2.3 227.72,85.44 ; S2.3 227.72,83.94 ; S2.3 226.66,84.69 ; 333.76,9.65 P19.1_5 ; P19.1_5 332.51,10.9 ; P19.1_5 335,10.9 ; P19.1_5 333.76,12.14 ; 205.62,11.51 R479.2 205.62,12.75 ; 287.81,123.95 A1.2 ; 365.85,51.69 P40.6 ; P40.6 367.03,52.87 ; P40.6 368.21,51.69 ; P40.6 367.03,50.51 ; 162.89,190.1 P12.GND1 ; P12.GND1 164.65,191.86 ; P12.GND1 161.12,191.86 ; P12.GND1 162.89,193.63 ; 91.54,38.99 C272.2 ; 277.62,101.82 P6.6 ; P6.6 276.44,103 ; P6.6 277.62,104.18 ; P6.6 278.8,103 ; 84.2,34.51 U41.8 ; U41.8 84.76,35.76 ; U41.8 83.64,35.76 ; 51.69,60.67 P21.10 ; P21.10 51.69,63.03 ; P21.10 50.51,61.85 ; P21.10 52.87,61.85 ; 207.01,124.49 C110.2 206.43,123.94 ; 213.81,15.17 C333.2 212.98,14.35 ; C16.1 104.34,84.6 ; C16.1 103.76,85.15 ; C16.1 103.17,84.6 ; 91.26,35.76 U41.2 ; U41.2 92.38,35.76 ; U41.2 91.82,34.51 ; 403.61,103.16 C300.2 404.48,103.91 ; SOMB.203 291.65,67.49 ; C258.2 81.62,107.76 ; C258.2 80.64,108.59 ; C258.2 79.67,107.76 ; P18.2_6 80.53,16.08 ; P18.2_6 79.29,14.83 ; P18.2_6 81.78,14.83 ; P18.2_6 80.53,13.59 ; 82.54,188.77 P14.25A ; P14.25A 85.03,188.77 ; P14.25A 83.78,187.53 ; 86.99,161.05 R325.2 86.42,161.67 ; 248.15,162.95 R211.2 248.15,164.2 ; P15.1 221.46,188.06 ; P15.1 220.34,186.94 ; P15.1 219.23,188.06 ; P15.1 220.34,189.18 ; 17.39,22.53 C377.2 17.39,23.7 ; 105.09,149.86 C235.2 ; C235.2 105.92,148.88 ; C235.2 105.92,150.84 ; 322.33,100.8 P23.1 ; P23.1 322.33,103.16 ; P23.1 323.51,101.98 ; P23.1 321.14,101.98 ; 254.62,105.16 R427.2 253.38,105.16 ; 120.9,72.23 SOMA.28 ; SOMB.133 274.14,67.49 ; 132.98,56.13 R67.1 134.23,56.13 ; 294.9,72.23 SOMB.216 ; C81.2 295.62,116.83 ; C81.2 294.64,117.66 ; C81.2 293.66,116.83 ; P33.9 324.87,87.54 ; P33.9 324.87,85.18 ; P33.9 323.68,86.36 ; P33.9 326.05,86.36 ; P20.6 48.26,75.73 ; P20.6 49.44,74.55 ; P20.6 48.26,73.37 ; P20.6 47.08,74.55 ; 304.81,112.85 C77.2 304.81,111.68 ; 144.36,103 P5.2 ; P5.2 145.54,101.82 ; P5.2 146.72,103 ; P33.7 327.41,87.54 ; P33.7 326.22,86.36 ; P33.7 328.59,86.36 ; P33.7 327.41,85.18 ; 342.2,8.05 P19.1_6 ; P19.1_6 343.45,6.81 ; P19.1_6 344.69,8.05 ; P19.1_6 343.45,9.3 ; 13.97,9.78 M1.2 ; M1.2 15.09,10.9 ; M1.2 13.97,12.01 ; M1.2 12.85,10.9 ; 39.97,19.62 R564.2 ; R564.2 39.32,20.37 ; R564.2 39.97,21.12 ; 87.82,149.86 C231.2 ; C231.2 88.65,148.88 ; C231.2 88.65,150.84 ; 92.05,178.64 P14.SH3 ; P14.SH3 94.18,180.77 ; P14.SH3 89.92,180.77 ; P14.SH3 92.05,182.91 ; 68.83,137.05 R337.2 69.46,137.63 ; P37.1 89.45,45.72 ; P37.1 88.27,44.54 ; P37.1 87.08,45.72 ; P37.1 88.27,46.9 ; SOMB.191 288.65,67.49 ; SOMA.181 159.14,67.49 ; P14.SH1 47.19,188.77 ; P14.SH1 42.93,188.77 ; P14.SH1 45.06,186.64 ; P14.SH1 45.06,190.91 ; R261.2 215.3,136.89 ; R261.2 215.3,135.39 ; R261.2 215.95,136.14 ; 365.85,72.01 P40.14 ; P40.14 368.21,72.01 ; P40.14 367.03,70.83 ; P40.14 367.03,73.19 ; 61.77,179.17 P14.5B ; P14.5B 63.02,177.93 ; P14.5B 64.26,179.17 ; P14.5B 63.02,180.42 ; 365.85,87.25 P40.20 ; P40.20 367.03,88.43 ; P40.20 367.03,86.07 ; P40.20 368.21,87.25 ; C194.2 97.16,127.2 ; U44.8 333.58,35.74 ; U44.8 333.02,34.48 ; U44.8 332.46,35.74 ; 62.74,89.24 DS21.C ; DS21.C 63.45,89.88 ; DS21.C 62.74,90.51 ; P21.18 52.87,82.17 ; P21.18 51.69,83.35 ; P21.18 50.51,82.17 ; P21.18 51.69,80.99 ; P6.8 281.34,103 ; P6.8 280.16,101.82 ; P6.8 278.98,103 ; P6.8 280.16,104.18 ; 146.7,137.63 R296.2 147.32,137.05 ; 213.3,21.79 C342.2 214.13,20.96 ; P20.8 48.26,70.65 ; P20.8 47.08,69.47 ; P20.8 48.26,68.29 ; P20.8 49.44,69.47 ; 235.95,30.07 C396.2 235.95,31.24 ; 83.78,180.77 P14.25B ; P14.25B 85.03,182.02 ; P14.25B 83.78,183.26 ; 136.51,161.05 R314.2 137.08,161.67 ; 218.45,23.35 C363.2 218.45,24.52 ; P12.GND2 152.57,191.86 ; P12.GND2 150.8,193.63 ; P12.GND2 149.04,191.86 ; P12.GND2 150.8,190.1 ; v2(205.84,19.31) 205.84,19.67 ; 385.84,28.87 U75.7 384.76,29.29 ; 127.77,88.47 R450.2 127.77,89.71 ; 122.65,104.88 C173.2 123.2,104.3 ; 95.06,161.67 R331.2 95.63,161.05 ; P19.1_3 339.29,12.14 ; P19.1_3 338.05,10.9 ; P19.1_3 340.54,10.9 ; P19.1_3 339.29,9.65 ; 229.76,37.92 R386.1 229.76,39.17 ; 229.1,164.2 R212.2 229.1,162.95 ; 321.14,94.11 P25.1 ; P25.1 322.33,95.29 ; P25.1 323.51,94.11 ; P25.1 322.33,92.93 ; 50.51,46.61 P21.4 ; P21.4 51.69,45.43 ; P21.4 52.87,46.61 ; P21.4 51.69,47.79 ; C206.2 136.49,122.01 ; C206.2 135.51,121.18 ; C206.2 134.53,122.01 ; 85.73,37.35 R538.2 85.73,38.6 ; 282.45,178.24 P16.11 ; P16.11 283.5,179.3 ; P16.11 284.56,178.24 ; P16.11 283.5,177.19 ; 99.78,45.72 P37.11 ; P37.11 100.97,44.54 ; P37.11 100.97,46.9 ; P37.11 102.15,45.72 ; 201.54,26.66 C322.2 202.09,27.24 ; 362.42,54.23 P39.14 ; P39.14 364.78,54.23 ; P39.14 363.6,53.05 ; P39.14 363.6,55.41 ; C199.2 136.49,125.03 ; C199.2 135.51,125.86 ; C199.2 134.53,125.03 ; v2(205.45,20.91) 205.8,20.91 ; 65.93,188.77 P14.19A ; P14.19A 68.42,188.77 ; P14.19A 67.17,187.53 ; P15.GND4 216.07,180.56 ; P15.GND4 212.54,180.56 ; P15.GND4 214.3,178.8 ; P15.GND4 214.3,182.33 ; 310.65,64.98 SOMB.279 ; 211.06,8.18 P9.SH2 ; P9.SH2 211.91,7.02 ; P9.SH2 212.77,8.18 ; P9.SH2 211.91,9.34 ; P6.2 272.54,104.18 ; P6.2 273.72,103 ; P6.2 271.36,103 ; P6.2 272.54,101.82 ; 146.36,24.4 C40.2 146.36,23.23 ; P19.2_5 335,17.65 ; P19.2_5 333.76,16.41 ; P19.2_5 333.76,18.9 ; P19.2_5 332.51,17.65 ; 385.06,21.92 C380.2 385.06,20.75 ; C201.2 135.51,134.5 ; C201.2 136.49,133.67 ; C201.2 134.53,133.67 ; SOMB.213 294.14,67.49 ; P16.16 263.86,181.09 ; P16.16 262.8,182.14 ; P16.16 262.8,180.03 ; P16.16 261.75,181.09 ; 220.23,117.93 C94.2 219.68,117.35 ; 303.65,64.98 303.65,66.24 ; C103.2 291.85,129.12 ; C103.2 291.85,127.24 ; C103.2 290.19,128.18 ; 210.65,135.39 R262.2 ; R262.2 210.65,136.89 ; R262.2 210.01,136.14 ; C433.2 183.89,122.53 ; C433.2 183.34,123.11 ; C433.2 183.34,121.94 ; P32.11 6.98,87.54 ; P32.11 5.8,86.36 ; P32.11 8.17,86.36 ; P32.11 6.98,85.18 ; 214.77,17.53 Y6.2 ; Y6.2 214.84,18.81 ; Y6.2 216.12,18.88 ; P20.18 48.26,45.25 ; P20.18 48.26,42.89 ; P20.18 49.44,44.07 ; P20.18 47.08,44.07 ; 47.08,84.71 P20.2 ; P20.2 48.26,85.89 ; P20.2 48.26,83.53 ; P20.2 49.44,84.71 ; 48.26,78.45 P20.4 ; P20.4 49.44,79.63 ; P20.4 48.26,80.81 ; P20.4 47.08,79.63 ; R283.2 119.12,119.24 ; 119.12,116.32 R278.2 119.12,115.07 ; P32.5 15.79,86.36 ; P32.5 14.6,87.54 ; P32.5 13.42,86.36 ; J1.S 34.8,6.63 ; J1.S 34.8,3.89 ; J1.S 36.17,5.26 ; J1.S 33.43,5.26 ; 287.64,180.03 P16.25 ; P16.25 286.59,181.09 ; P16.25 287.64,182.14 ; P16.25 288.7,181.09 ; 306.82,162.95 R156.2 306.82,164.2 ; C205.2 135.51,117.22 ; C205.2 136.49,116.4 ; C205.2 134.53,116.4 ; 234.78,86.63 U52.8 235.45,87.02 ; 147.32,127.26 R293.2 146.7,126.69 ; P15.GND3 228.15,180.56 ; P15.GND3 226.39,178.8 ; P15.GND3 224.62,180.56 ; P15.GND3 226.39,182.33 ; 48.26,63.21 P20.10 ; P20.10 47.08,64.39 ; P20.10 48.26,65.57 ; P20.10 49.44,64.39 ; 74.23,188.77 P14.22A ; P14.22A 76.72,188.77 ; P14.22A 75.48,187.53 ; 177.25,101.98 P22.1 ; P22.1 179.62,101.98 ; P22.1 178.43,100.8 ; P22.1 178.43,103.16 ; 88.27,47.08 P37.2 ; P37.2 88.27,49.44 ; P37.2 89.45,48.26 ; P37.2 87.08,48.26 ; C192.2 118.99,127.2 ; 122.65,103.1 C170.2 123.2,103.69 ; 253.63,24.4 C67.2 253.63,23.23 ; P14.2A 55.96,185.93 ; P14.2A 54.71,187.17 ; P14.2A 53.47,185.93 ; P14.2A 54.71,184.68 ; 367.03,80.99 P40.18 ; P40.18 367.03,83.35 ; P40.18 365.85,82.17 ; P40.18 368.21,82.17 ; R207.2 273.98,136.89 ; R207.2 273.98,135.39 ; R207.2 274.63,136.14 ; 396.99,151.63 R438.2 396.99,150.38 ; 119.05,190.1 P11.GND2 ; P11.GND2 120.82,191.86 ; P11.GND2 117.29,191.86 ; P11.GND2 119.05,193.63 ; 281.42,88.32 R28.2 280.17,88.32 ; C202.2 136.49,139.28 ; C202.2 135.51,138.45 ; C202.2 134.53,139.28 ; R205.2 293.68,136.14 ; R205.2 293.03,136.89 ; R205.2 293.03,135.39 ; P39.4 364.78,79.63 ; P39.4 363.6,78.45 ; P39.4 363.6,80.81 ; P39.4 362.42,79.63 ; 220.23,115.75 C86.2 ; P16.19 272.14,181.09 ; P16.19 271.08,182.14 ; P16.19 271.08,180.03 ; P16.19 270.03,181.09 ; 312.47,149.48 U23.4 ; U23.4 313.82,148.92 ; U23.4 313.82,150.04 ; 376.56,24.31 C381.2 376.56,25.48 ; 254.77,89.99 R458.2 254.77,91.24 ; U42.13 75.74,26.47 ; U42.13 75.18,27.72 ; U42.13 74.62,26.47 ; 220.73,111.81 C108.2 220.73,112.98 ; U42.9 70.1,27.72 ; U42.9 69.54,26.47 ; U42.9 70.66,26.47 ; 275.08,101.82 P6.4 ; P6.4 276.26,103 ; P6.4 273.9,103 ; P6.4 275.08,104.18 ; 18.17,28.87 U74.7 17.09,29.29 ; 220.73,111.2 C265.2 220.73,110.03 ; C317.2 390.02,141.64 ; C317.2 391.3,140.84 ; C317.2 390.02,140.04 ; C317.2 388.73,140.84 ; 150.76,92.63 R590.2 150.76,91.39 ; P35.17 200.69,80.24 ; 68.21,25.41 R357.2 69.46,25.41 ; 247.02,145.75 C139.2 246.48,145.16 ; 226.39,190.1 P15.GND1 ; P15.GND1 226.39,193.63 ; P15.GND1 224.62,191.86 ; P15.GND1 228.15,191.86 ; 362.42,74.55 P39.6 ; P39.6 363.6,75.73 ; P39.6 364.78,74.55 ; P39.6 363.6,73.37 ; 182.55,178.8 P13.GND4 ; P13.GND4 180.79,180.56 ; P13.GND4 184.32,180.56 ; P13.GND4 182.55,182.33 ; P16.2 258.66,179.3 ; P16.2 259.72,178.24 ; P16.2 258.66,177.19 ; P16.2 257.61,178.24 ; 135.5,56.13 R72.1 134.25,56.13 ; 134.53,107.76 C203.2 ; C203.2 136.49,107.76 ; C203.2 135.51,108.59 ; 211.94,18.59 Y6.4 ; Y6.4 211.87,17.32 ; Y6.4 213.22,18.67 ; Y6.4 213.15,17.39 ; 158.25,88.32 R27.2 159.5,88.32 ; 215.73,34.1 U58.8 ; U58.8 216.42,33.73 ; U58.8 217.12,34.1 ; C320.2 403.73,178.88 ; C320.2 402.88,177.95 ; C320.2 404.58,177.95 ; C320.2 403.73,177.03 ; C296.2 393.65,107.19 ; C296.2 392.75,108.24 ; C296.2 392.75,106.13 ; 112.9,161.05 R311.2 112.33,161.67 ; P33.5 329.95,87.54 ; P33.5 328.76,86.36 ; P33.5 331.13,86.36 ; 61.77,185.93 P14.5A ; P14.5A 63.02,187.17 ; P14.5A 63.02,184.68 ; P14.5A 64.26,185.93 ; 10.88,86.36 P32.7 ; P32.7 13.25,86.36 ; P32.7 12.06,85.18 ; P32.7 12.06,87.54 ; 362.42,64.39 P39.10 ; P39.10 363.6,63.21 ; P39.10 363.6,65.57 ; P39.10 364.78,64.39 ; C236.2 100.31,150.84 ; C236.2 101.13,149.86 ; C236.2 100.31,148.88 ; SOMA.73 132.15,67.49 ; 135.52,56.13 R53.1 136.77,56.13 ; 110.6,161.05 R312.2 111.17,161.67 ; P14.22B 75.48,183.26 ; P14.22B 75.48,180.77 ; P14.22B 74.23,182.02 ; 145.33,73.49 SOMA.124 144.9,72.23 ; 78.43,26.47 U42.16 ; U42.16 79.55,26.47 ; U42.16 78.99,27.72 ; 126.63,20.69 C37.2 126.63,21.86 ; 128.66,43.39 R77.1 ; 79.67,133.67 C248.2 ; C248.2 81.62,133.67 ; C248.2 80.64,134.5 ; R179.2 314.25,136.14 ; R179.2 313.6,136.89 ; R179.2 313.6,135.39 ; 179.4,72.23 SOMA.262 ; 33.78,28.28 C387.2 33.2,27.73 ; 219.68,84.56 S1.3 ; S1.3 220.73,83.81 ; S1.3 220.73,85.31 ; P40.16 367.03,78.27 ; P40.16 365.85,77.09 ; P40.16 368.21,77.09 ; P40.16 367.03,75.91 ; 102.95,110.48 C179.2 101.78,110.48 ; 130.17,161.05 R315.2 129.6,161.67 ; P9.SH3 212.77,3.45 ; P9.SH3 211.91,4.61 ; P9.SH3 211.06,3.45 ; 42.93,180.77 P14.SH2 ; P14.SH2 47.19,180.77 ; P14.SH2 45.06,178.64 ; P14.SH2 45.06,182.91 ; 80.64,121.18 C255.2 ; C255.2 81.62,122.01 ; C255.2 79.67,122.01 ; 334.78,162.95 R153.2 334.78,164.2 ; SOMA.121 144.14,67.49 ; 127.87,161.05 R316.2 128.44,161.67 ; C392.2 406.06,16.37 ; C392.2 403.95,16.37 ; C392.2 405,17.27 ; P6.10 282.7,104.18 ; P6.10 282.7,101.82 ; P6.10 283.88,103 ; P6.10 281.52,103 ; 126.39,72.23 SOMA.50 ; 278.31,181.09 P16.22 ; P16.22 279.36,182.14 ; P16.22 279.36,180.03 ; P16.22 280.42,181.09 ; 404.48,149.5 C301.2 403.61,148.75 ; SOMA.213 167.14,67.49 ; 334.55,38.57 R557.2 334.55,37.32 ; 141.39,72.23 SOMA.110 ; 253.63,20.69 C66.2 253.63,21.86 ; 161.42,76.26 P38.4 ; P38.4 160.53,78.11 ; P38.4 162.31,78.11 ; P38.4 161.42,79.95 ; 237.61,37.92 R387.1 238.18,38.54 ; P12.1 157.96,188.06 ; P12.1 155.73,188.06 ; P12.1 156.84,186.94 ; P12.1 156.84,189.18 ; 346.47,25.38 R364.2 345.22,25.38 ; 399.99,156.08 R440.2 ; R440.2 400.57,155.46 ; R440.2 400.57,156.71 ; 70.84,9.68 P18.1_5 ; P18.1_5 69.6,10.92 ; P18.1_5 72.09,10.92 ; P18.1_5 70.84,12.17 ; U43.9 347.68,26.44 ; U43.9 346.56,26.44 ; U43.9 347.12,27.7 ; 125.09,186.94 P11.1 ; P11.1 126.21,188.06 ; P11.1 125.09,189.18 ; P11.1 123.98,188.06 ; 235.88,135.39 R235.2 ; R235.2 236.53,136.14 ; R235.2 235.88,136.89 ; 298.46,112.98 C97.2 298.46,111.81 ; 101.96,161.05 R330.2 102.53,161.67 ; 178.43,92.93 P24.1 ; P24.1 179.62,94.11 ; P24.1 177.25,94.11 ; P24.1 178.43,95.29 ; C104.2 214.12,129.12 ; C104.2 212.47,128.18 ; C104.2 214.12,127.24 ; 284.73,124.49 C109.2 284.15,123.94 ; 194.56,10.86 P34.5 193.94,9.21 ; 257.67,105.16 R429.2 256.43,105.16 ; C233.2 80.01,150.84 ; C233.2 80.01,148.88 ; C233.2 79.18,149.86 ; 212.04,32.84 C367.2 211.45,32.29 ; 187.33,87.71 C431.2 187.33,86.54 ; 348.65,37.32 R553.2 348.65,38.57 ; 79.63,177.93 P14.11B ; P14.11B 80.87,179.17 ; P14.11B 79.63,180.42 ; 285.24,101.82 P6.12 ; P6.12 284.06,103 ; P6.12 285.24,104.18 ; P6.12 286.42,103 ; R236.2 231.23,136.89 ; R236.2 230.58,136.14 ; R236.2 231.23,135.39 ; 397.69,23.66 C393.2 398.86,23.66 ; 196.47,148.92 U29.4 ; U29.4 195.12,149.48 ; U29.4 196.47,150.04 ; P21.6 51.69,52.87 ; P21.6 51.69,50.51 ; P21.6 52.87,51.69 ; P21.6 50.51,51.69 ; 146.71,66.24 SOMA.133 147.14,67.49 ; 290.32,101.82 P6.16 ; P6.16 291.5,103 ; P6.16 290.32,104.18 ; P6.16 289.14,103 ; 325.87,162.95 R155.2 325.87,164.2 ; 26.3,14.29 R567.2 26.3,15.53 ; 194.05,26.28 C353.2 194.05,27.45 ; 341.35,26.44 U44.16 ; U44.16 341.91,27.7 ; U44.16 342.47,26.44 ; 213.49,63.47 C9.2 212.9,62.92 ; 204.16,9.33 P9.B12 ; 287.53,78.11 P42.4 ; P42.4 289.31,78.11 ; P42.4 288.42,79.95 ; P42.4 288.42,76.26 ; 261.25,56.13 R104.1 262.5,56.13 ; 115.39,132.83 C181.2 114.22,132.83 ; 340.08,35.74 U44.2 ; U44.2 340.64,34.48 ; U44.2 341.2,35.74 ; 354.74,34.48 U43.2 ; U43.2 355.3,35.74 ; U43.2 354.18,35.74 ; 363.6,37.81 P39.20 ; P39.20 363.6,40.17 ; P39.20 362.42,38.99 ; P39.20 364.78,38.99 ; 365.85,41.53 P40.2 368.21,41.53 ; 198.38,164.2 R238.2 198.38,162.95 ; 111.41,103.1 C168.2 111.96,103.69 ; 212.04,35.87 C368.2 211.45,36.42 ; 139.5,91.24 C8.2 140.67,91.24 ; 296.88,117.86 C79.2 295.71,117.86 ; P11.GND4 120.82,180.56 ; P11.GND4 119.05,182.33 ; P11.GND4 117.29,180.56 ; P11.GND4 119.05,178.8 ; P39.2 363.6,85.89 ; P39.2 363.6,83.53 ; P39.2 362.42,84.71 ; P39.2 364.78,84.71 ; 269.33,135.39 R208.2 ; R208.2 268.68,136.14 ; R208.2 269.33,136.89 ; 146.7,118.05 R299.2 147.32,118.62 ; 80.53,6.83 P18.1_6 ; P18.1_6 80.53,9.32 ; P18.1_6 81.78,8.08 ; P18.1_6 79.29,8.08 ; P13.GND2 182.55,193.63 ; P13.GND2 180.79,191.86 ; P13.GND2 182.55,190.1 ; P13.GND2 184.32,191.86 ; 159.6,103 P5.14 ; P5.14 160.78,101.82 ; P5.14 161.96,103 ; 227.08,110.03 C92.2 227.08,111.2 ; R91.1 256.54,51.81 ; SOMA.279 183.65,67.49 ; 138.81,161.05 R313.2 138.24,161.67 ; P37.12 100.97,49.44 ; P37.12 99.78,48.26 ; P37.12 102.15,48.26 ; P37.12 100.97,47.08 ; 151.98,103 P5.8 ; P5.8 153.16,101.82 ; P5.8 154.34,103 ; 117.58,148.88 C216.2 ; C216.2 118.41,149.86 ; C216.2 117.58,150.84 ; C310.2 392.75,174.28 ; C310.2 393.65,173.23 ; C310.2 392.75,172.17 ; 79.63,184.68 P14.11A ; P14.11A 78.38,185.93 ; P14.11A 79.63,187.17 ; 8.9,24.31 C376.2 8.9,25.48 ; P18.2_3 76.38,18.92 ; P18.2_3 75.13,17.68 ; P18.2_3 77.62,17.68 ; P18.2_3 76.38,16.43 ; P9.SH1 203.38,9.34 ; P9.SH1 202.52,8.18 ; P9.SH1 203.38,7.02 ; P9.SH1 204.23,8.18 ; 25.41,100.08 R421.2 26.66,100.08 ; P21.16 51.69,78.27 ; P21.16 51.69,75.91 ; P21.16 52.87,77.09 ; P21.16 50.51,77.09 ; 91.54,37.97 C270.2 ; P15.GND2 214.3,193.63 ; P15.GND2 214.3,190.1 ; P15.GND2 212.54,191.86 ; P15.GND2 216.07,191.86 ; 76.38,9.68 P18.1_3 ; P18.1_3 76.38,12.17 ; P18.1_3 77.62,10.92 ; P18.1_3 75.13,10.92 ; U42.2 78.28,35.76 ; U42.2 77.16,35.76 ; U42.2 77.72,34.51 ; 50.51,66.93 P21.12 ; P21.12 52.87,66.93 ; P21.12 51.69,65.75 ; P21.12 51.69,68.11 ; 215.52,148.92 U28.4 ; U28.4 215.52,150.04 ; U28.4 214.17,149.48 ; 338.05,17.65 P19.2_3 ; P19.2_3 339.29,16.41 ; P19.2_3 340.54,17.65 ; P19.2_3 339.29,18.9 ; M2.2 382.75,10.9 ; M2.2 381.63,9.78 ; M2.2 380.52,10.9 ; M2.2 381.63,12.01 ; 38.67,27.79 U70.5 ; U70.5 39.24,28.96 ; U70.5 39.24,26.62 ; 305,127.51 C89.2 ; C89.2 305.83,128.49 ; C89.2 305.83,126.53 ; 403.61,126.02 C313.2 404.48,126.77 ; 400.57,151.63 R444.2 400.57,150.38 ; 288.38,135.39 R206.2 ; R206.2 288.38,136.89 ; R206.2 287.73,136.14 ; P9.B1 211.13,9.33 ; 28.18,100.08 R422.2 26.94,100.08 ; P39.12 364.78,59.31 ; P39.12 362.42,59.31 ; P39.12 363.6,58.13 ; P39.12 363.6,60.49 ; SOMB.27 247.64,67.49 ; 273.36,21.86 C63.2 273.36,20.69 ; 131,149.86 C221.2 ; C221.2 131.83,148.88 ; C221.2 131.83,150.84 ; 146.7,120.35 R300.2 147.32,119.78 ; DS22.C 378.79,89.88 ; DS22.C 378.08,90.51 ; DS22.C 378.08,89.24 ; P14.2B 54.71,180.42 ; P14.2B 54.71,177.93 ; P14.2B 55.96,179.17 ; P14.2B 53.47,179.17 ; P40.12 367.03,68.11 ; P40.12 365.85,66.93 ; P40.12 368.21,66.93 ; P40.12 367.03,65.75 ; 396.99,128.89 R447.2 396.99,127.65 ; 207.51,37.45 C326.2 207.51,38.62 ; SOMB.71 258.64,67.49 ; C82.2 217.89,116.83 ; C82.2 215.94,116.83 ; C82.2 216.92,117.66 ; 234.78,94.12 U14.8 235.45,94.52 ; 265.53,145.16 C126.2 266.07,145.75 ; 305.89,72.23 SOMB.260 ; 400.57,172.07 R454.2 400.57,170.83 ; 103.69,161.67 R329.2 104.26,161.05 ; 237.75,89.02 U52.13 239.1,89.02 ; SOMA.97 138.15,67.49 ; R537.2 88.27,38.6 ; 153.17,88.32 R23.2 154.42,88.32 ; U15.8 235.45,79.91 ; 80.64,138.45 C247.2 ; C247.2 79.67,139.28 ; C247.2 81.62,139.28 ; R75.1 128.66,45.71 ; U26.4 255.14,150.04 ; U26.4 255.14,148.92 ; U26.4 253.8,149.48 ; R107.1 255.66,45.71 ; 17.39,20.75 C374.2 17.39,21.92 ; R483.2 224.53,14.78 ; 315.73,164.2 R154.2 315.73,162.95 ; 117.11,131.48 C191.2 ; C191.2 118.61,131.48 ; C191.2 117.86,130.76 ; 215.94,127.01 C100.2 ; C100.2 216.92,126.18 ; C100.2 217.89,127.01 ; 305.7,145.75 C112.2 305.15,145.16 ; 384.18,14.78 M2.6 ; M2.6 384.18,17.01 ; M2.6 385.29,15.9 ; 79.67,125.03 C250.2 ; C250.2 81.62,125.03 ; C250.2 80.64,125.86 ; 207.4,145.75 C153.2 206.85,145.16 ; 240.15,83.87 C73.2 240.15,85.04 ; 331.52,149.48 U22.4 ; U22.4 332.87,150.04 ; U22.4 332.87,148.92 ; 257.06,164.2 R209.2 257.06,162.95 ; C183.2 113.74,132.83 ; 258.9,72.23 SOMB.72 ; 50.51,87.25 P21.20 ; P21.20 51.69,88.43 ; P21.20 51.69,86.07 ; P21.20 52.87,87.25 ; 31.19,23.66 C385.2 30.02,23.66 ; 70.1,34.51 U42.8 ; U42.8 70.66,35.76 ; U42.8 69.54,35.76 ; R93.1 257.68,51.81 ; 210.8,10.58 P9.A12 210.4,11.43 ; 57.62,188.77 P14.16A ; P14.16A 58.86,187.53 ; P14.16A 58.86,190.02 ; 394.35,24.31 U73.3 394.91,23.46 ; 84.69,161.05 R326.2 85.26,161.67 ; 23.89,100.08 R420.2 25.13,100.08 ; 82.31,25.41 R356.2 83.55,25.41 ; SOMA.145 150.14,67.49 ; P13.1 189.71,188.06 ; P13.1 188.59,189.18 ; P13.1 187.48,188.06 ; P13.1 188.59,186.94 ; M1.6 16.51,17.01 ; M1.6 16.51,14.78 ; M1.6 17.63,15.9 ; P18.2_5 70.84,18.92 ; P18.2_5 69.6,17.68 ; P18.2_5 70.84,16.43 ; P18.2_5 72.09,17.68 ; 261.23,56.13 R99.1 259.98,56.13 ; 310.4,72.23 SOMB.278 ; SOMA.223 169.65,67.49 ; 97.28,148.88 C237.2 ; C237.2 96.46,149.86 ; C237.2 97.28,150.84 ; 150.8,178.8 P12.GND4 ; P12.GND4 152.57,180.56 ; P12.GND4 149.04,180.56 ; P12.GND4 150.8,182.33 ; 156.96,88.32 R26.2 155.71,88.32 ; U24.4 293.24,150.04 ; U24.4 291.9,149.48 ; U24.4 293.24,148.92 ; 382.27,82.49 P31.12 ; R556.2 337.09,38.57 ; 123.19,148.88 C215.2 ; C215.2 122.36,149.86 ; C215.2 123.19,150.84 ; 50.51,41.53 P21.2 ; P21.2 51.69,40.35 ; P21.2 52.87,41.53 ; P21.2 51.69,42.71 ; 403.61,169.2 C314.2 404.48,169.95 ; 134.53,113.37 C204.2 ; C204.2 136.49,113.37 ; C204.2 135.51,112.55 ; 355.45,26.44 U43.16 ; U43.16 356.01,27.7 ; U43.16 356.57,26.44 ; P6.14 287.78,104.18 ; P6.14 288.96,103 ; P6.14 286.6,103 ; P6.14 287.78,101.82 ; P13.GND1 196.4,191.86 ; P13.GND1 194.64,190.1 ; P13.GND1 194.64,193.63 ; P13.GND1 192.87,191.86 ; C219.2 140.46,150.84 ; C219.2 140.46,148.88 ; C219.2 139.64,149.86 ; 31.51,100.08 R425.2 32.75,100.08 ; C13.2 263.98,118.05 ; 396.99,106.03 R439.2 396.99,104.79 ; 148.08,101.82 P5.4 ; P5.4 149.26,103 ; P5.4 146.9,103 ; 212.34,89.2 C23.2 212.88,89.79 ; 77.44,37.97 C271.2 ; 225.5,38.54 R384.1 226.07,37.92 ; C222.2 126.22,150.84 ; C222.2 127.04,149.86 ; C222.2 126.22,148.88 ; 188.35,145.75 C154.2 187.8,145.16 ; 217.98,117.86 C80.2 219.15,117.86 ; 210.08,123.95 A2.2 ; 80.64,129.82 C249.2 ; C249.2 81.62,130.64 ; C249.2 79.67,130.64 ; 259.47,105.16 R431.2 260.72,105.16 ; C107.2 305.34,125.98 ; 185.34,128.59 C76.2 186.51,128.59 ; 154.52,103 P5.10 ; P5.10 156.88,103 ; P5.10 155.7,101.82 ; 385.06,22.53 C369.2 385.06,23.7 ; 147.32,109.99 R297.2 146.7,109.42 ; P20.14 49.44,54.23 ; P20.14 48.26,55.41 ; P20.14 47.08,54.23 ; P20.14 48.26,53.05 ; 307.14,64.98 SOMB.265 ; 147.32,135.9 R295.2 146.7,135.32 ; U56.1 195.44,28.64 ; U56.1 194.55,27.84 ; U56.1 193.66,28.64 ; U56.1 194.55,29.44 ; 237.75,89.52 U52.14 239.1,89.52 ; 194.05,22.11 C321.2 194.05,20.94 ; 324.2,145.16 C111.2 324.75,145.75 ; 113.73,149.86 C217.2 ; C217.2 114.55,150.84 ; C217.2 114.55,148.88 ; 127.77,89.99 R449.2 127.77,91.24 ; 98.3,130.76 C188.2 ; C188.2 97.55,131.48 ; C188.2 99.05,131.48 ; 273.36,24.4 C65.2 273.36,23.23 ; 111.96,104.3 C172.2 111.41,104.88 ; 400.86,27.73 C398.2 401.45,28.28 ; SOMA.229 171.14,67.49 ; 293.61,117.86 R149.2 292.37,117.86 ; 257.95,105.16 R430.2 259.19,105.16 ; 198.49,79.31 P35.19 199.42,80.24 ; 69.47,82.49 P30.8 ; 76.05,161.05 R328.2 76.63,161.67 ; 29.71,100.08 R423.2 28.46,100.08 ; 293.66,127.01 C99.2 ; C99.2 294.64,126.18 ; C99.2 295.62,127.01 ; 77.44,38.99 C273.2 ; 365.85,46.61 P40.4 368.21,46.61 ; 69.46,109.42 R348.2 68.83,109.99 ; 183.34,123.29 C432.2 ; C432.2 183.34,124.46 ; C432.2 183.89,123.88 ; C96.2 219.02,125.85 ; 234.45,37.92 R385.1 ; 332.37,25.38 R365.2 331.13,25.38 ; SOMB.223 296.65,67.49 ; 204.89,11.43 P9.A1 204.49,10.58 ; P35.15 201.96,80.24 ; 255.66,43.39 R109.1 ; P14.8A 71.32,187.17 ; P14.8A 71.32,184.68 ; P14.8A 70.08,185.93 ; 406.34,27.79 U72.5 ; U72.5 406.91,28.96 ; U72.5 406.91,26.62 ; 227.08,111.68 C78.2 227.08,112.85 ; 136.79,56.13 R55.1 ; P14.19B 68.42,182.02 ; P14.19B 67.17,180.77 ; P14.19B 67.17,183.26 ; 68.83,127.26 R340.2 69.46,126.69 ; 263.79,56.13 R87.1 ; 287.39,72.23 SOMB.186 ; C95.2 296.75,125.85 ; 292.39,72.23 SOMB.206 ; 131.9,72.23 SOMA.72 ; 267.2,164.2 R184.2 267.2,162.95 ; 220.87,21.15 U59.3 ; 27.24,23.46 U71.3 26.68,24.31 ; 217.43,164.2 R237.2 217.43,162.95 ; R59.1 129.54,51.81 ; 295.16,162.95 R181.2 295.16,164.2 ; 273.96,73.49 SOMB.134 274.39,72.23 ; 240.78,82.31 R122.2 240.78,83.55 ; 300.39,72.23 SOMB.238 ; 119.23,161.05 R310.2 119.81,161.67 ; 211.47,24.96 C335.2 210.93,24.37 ; 193.29,10.86 P34.3 193.92,9.21 ; R523.2 204.27,71.95 ; 351.64,26.44 U43.13 ; U43.13 352.2,27.7 ; U43.13 352.76,26.44 ; 71.64,37.35 R542.2 71.64,38.6 ; 68.83,111.15 R347.2 69.46,111.72 ; 283.96,88.32 R29.2 282.71,88.32 ; 68.83,119.78 R345.2 69.46,120.35 ; SOMA.71 131.64,67.49 ; 206.24,21.35 v2(206.24,21.71) ; U44.9 333.58,26.44 ; U44.9 333.02,27.7 ; U44.9 332.46,26.44 ; 284.58,145.16 C125.2 285.12,145.75 ; 214.64,117.86 R150.2 215.89,117.86 ; SOMB.169 283.14,67.49 ; 393.96,15.53 R572.2 393.96,14.29 ; 346.56,35.74 U43.8 ; U43.8 347.68,35.74 ; U43.8 347.12,34.48 ; SOMB.145 277.14,67.49 ; 262.52,56.13 R85.1 263.77,56.13 ; 79.67,116.4 C256.2 ; C256.2 81.62,116.4 ; C256.2 80.64,117.22 ; 208.8,87.38 U9.11 ; C12.2 36.02,112.97 ; 400.57,127.65 R453.2 400.57,128.89 ; R545.2 351.19,38.57 ; 119.12,116.85 R282.2 ; 284.39,72.23 SOMB.174 ; C232.2 83.86,149.86 ; C232.2 83.04,150.84 ; C232.2 83.04,148.88 ; 126.63,23.23 C39.2 126.63,24.4 ; 160.39,72.23 SOMA.186 ; SOMB.97 265.15,67.49 ; SOMA.27 120.64,67.49 ; 228.1,126.53 C90.2 ; C90.2 227.28,127.51 ; C90.2 228.1,128.49 ; 146.7,128.99 R294.2 147.32,128.42 ; 136.39,72.23 SOMA.90 ; 177.25,109.86 P26.1 ; P26.1 178.43,111.04 ; P26.1 179.62,109.86 ; P26.1 178.43,108.67 ; 268.39,72.23 SOMB.110 ; SOMA.109 141.15,67.49 ; R233.2 255.58,136.14 ; R233.2 254.93,135.39 ; R233.2 254.93,136.89 ; SOMA.191 161.65,67.49 ; 298.14,64.98 SOMB.229 ; 307.89,72.23 SOMB.268 ; R264.2 191.6,136.89 ; R264.2 190.96,136.14 ; R264.2 191.6,135.39 ; SOMB.85 262.15,67.49 ; SOMA.169 156.14,67.49 ; C220.2 134.85,150.84 ; C220.2 135.68,149.86 ; C220.2 134.85,148.88 ; 165.39,72.23 SOMA.206 ; 221.48,23.35 C366.2 221.48,24.52 ; 187.33,86.18 C430.2 187.33,85.01 ; 155.39,72.23 SOMA.166 ; R139.2 306.32,114.56 ; 146.36,21.86 C41.2 146.36,20.69 ; 396.99,172.07 R448.2 396.99,170.83 ; 253.1,105.16 R426.2 251.85,105.16 ; 173.39,72.23 SOMA.238 ; 80.64,112.55 C257.2 ; C257.2 81.62,113.37 ; C257.2 79.67,113.37 ; P35.3 209.58,80.24 ; 240.15,92.15 C26.2 240.15,90.98 ; SOMA.251 176.65,67.49 ; 238.01,164.2 R210.2 238.01,162.95 ; 274.19,148.92 U25.4 ; U25.4 272.85,149.48 ; U25.4 274.19,150.04 ; 256.15,105.16 R428.2 254.9,105.16 ; 181.79,129.07 Y3.2 ; Y3.2 183.39,129.07 ; Y3.2 182.59,129.82 ; 167.9,72.23 SOMA.216 ; 68.83,135.9 R338.2 69.46,135.32 ; 147.39,72.23 SOMA.134 146.96,73.49 ; 121.54,161.05 R309.2 120.96,161.67 ; 227.43,145.16 C140.2 227.97,145.75 ; R550.2 232.65,29.38 ; 240.78,96.91 R121.2 240.78,98.16 ; SOMA.85 135.15,67.49 ; SOMB.181 286.14,67.49 ; 384.81,82.49 P31.8 ; SOMB.73 259.15,67.49 ; 157.39,72.23 SOMA.174 ; C98.2 227.61,125.98 ; P35.5 208.31,80.24 ; SOMB.121 271.15,67.49 ; 158.9,72.23 SOMA.180 ; 150.9,72.23 SOMA.148 ; 66.93,82.49 P30.12 ; 306.4,72.23 SOMB.262 ; 340.35,37.95 C280.2 ; 362.42,44.07 P39.18 364.78,44.07 ; 271.9,72.23 SOMB.124 272.33,73.49 ; 285.9,72.23 SOMB.180 ; SOMB.49 253.15,67.49 ; 68.83,128.42 R339.2 69.46,128.99 ; R61.1 130.68,51.81 ; 354.45,38.96 C283.2 ; SOMA.235 172.65,67.49 ; SOMA.203 164.65,67.49 ; 209.92,14.66 R463.2 ; 297.95,115.75 C93.2 ; 308.89,72.23 SOMB.272 ; 206.76,24.37 C338.2 ; SOMA.49 126.15,67.49 ; 253.39,72.23 SOMB.50 ; 29.98,100.08 R424.2 31.23,100.08 ; 232.65,27.03 C395.2 ; SOMB.193 289.14,67.49 ; 340.35,38.96 C282.2 ; 400.57,104.79 R443.2 400.57,106.03 ; 178.89,72.23 SOMA.260 ; SOMA.157 153.14,67.49 ; 247.9,72.23 SOMB.28 ; 181.89,72.23 SOMA.272 ; 289.9,72.23 SOMB.196 ; R266.2 128.77,100.57 ; SOMB.157 280.14,67.49 ; 208.8,88.03 U9.12 ; 277.9,72.23 SOMB.148 ; 299.65,64.98 SOMB.235 ; 263.39,72.23 SOMB.90 ; 183.4,72.23 SOMA.278 ; 282.39,72.23 SOMB.166 ; SOMA.265 180.14,67.49 ; 196.48,48.33 R491.2 ; R541.2 74.18,38.6 ; 180.89,72.23 SOMA.268 ; SOMA.193 162.14,67.49
  TOP w0.305: 205.22,85.43 U9.7 204.14,85.01 ; 218,13.13 C347.2 ; C347.2 v1(217.31,13.59) ; C347.2 218,14.05 ; R473.2 v1(203.71,27.98) ; 207.23,36.44 C325.2 ; C325.2 207.23,37.35 ; C325.2 v1(207.84,36.89) ; P9.A12 210.4,9.38 P9.B1 ; U33.13 99.33,120.04 v1(99.05,119.76) 99.05,119.7 99.35,119.39 U33.14 ; R465.2 v1(208.06,34.35) ; R465.2 207.45,33.9 ; R465.2 207.45,34.81 ; U33.80 v1(101.9,127.64) ; U33.61 v1(114.25,127.74) ; P9.A1 204.89,9.38 P9.B12 ; U33.30 v1(107.75,112.41) ; U33.26 105.15,112.26 C197.2 ; U33.21 v1(101.9,115.7) ; 211,38.1 211.45,38.1 ; 211.45,38.1 v1(211.45,38.72) ; 211.45,38.1 211.91,38.1
  TOP w0.432: 199.7,32.61 U53.4 ; U53.4 200.43,33.08 ; U53.4 198.98,33.08 ; U53.4 199.7,33.55
  TOP w0.508: P31.8 v1(384.81,86.12) ; C26.2 v1(241.12,91.57) ; v1(392.18,163.2) v1(392.18,163.83) v1(391.54,163.83) ; R429.2 v1(257.05,104.26) ; R53.1 v1(136.14,56.9) ; C205.2 v1(135.51,115.37) ; R27.2 v1(158.88,89.02) ; U42.16 v1(78.99,24.57) ; R112.1 v1(255.66,38.47) ; C306.2 390.28,163.83 v1(391.54,163.83) ; C257.2 v1(80.64,114.4) ; C335.2 v1(210.93,25.67) ; C13.2 v1(263.4,117.38) ; R235.2 v1(235.1,136.14) ; C355.2 v1(221.4,14.17) ; C188.2 v1(98.3,132.41) ; C202.2 v1(135.51,140.31) ; R104.1 v1(261.87,56.9) ; C199.2 v1(135.51,124) ; C95.2 v1(296.16,126.6) ; R55.1 v1(137.41,56.9) ; C219.2 v1(141.49,149.86) ; C41.2 v1(147.03,21.27) ; v1(210.7,15.28) R463.2 C323.2 ; C395.2 v1(231.77,27.61) ; C81.2 v1(294.64,115.8) ; U41.16 v1(93.09,24.57) ; C321.2 v1(194.8,21.53) ; v1(340.9,39.75) C282.2 C280.2 v1(340.9,37.24) 340.64,36.97 U44.2 ; A2.2 v1(212.32,123.95) ; R387.1 v1(237.61,39.29) ; C385.2 v1(30.61,24.49) ; U44.8 v1(333.02,37.63) ; C339.2 v1(221.47,8.83) ; C203.2 v1(135.51,106.73) ; R386.1 v1(229.23,39.29) ; C366.2 v1(222.31,23.94) ; R311.2 v1(112.9,162.42) ; R156.2 v1(307.52,163.58) ; U42.8 v1(70.1,37.66) ; R328.2 v1(76.05,162.42) ; C336.2 v1(221.47,9.84) ; C333.2 v1(213.87,14.28) ; C235.2 v1(106.95,149.86) ; R447.2 v1(397.77,128.27) ; v1(391.54,141.1) v1(392.18,141.1) v1(392.18,140.46) ; v1(391.54,141.1) 390.28,141.1 C317.2 ; v1(391.54,141.1) v1(391.54,140.46) ; S1.3 v1(221.99,84.56) ; R556.2 v1(336.32,37.95) ; C100.2 v1(216.92,128.17) ; R178.2 v1(328.78,136.14) ; C39.2 v1(125.95,23.81) ; TP28.1 v1(400.37,111.37) ; U24.4 v1(294.79,149.48) ; R109.1 v1(254.83,44.01) ; R211.2 v1(248.85,163.58) ; R80.1 v1(128.66,38.47) ; C232.2 v1(82.01,149.86) ; R122.2 v1(241.56,82.93) ; R124.2 v1(307.47,107.18) ; R444.2 v1(399.79,151) ; R326.2 v1(84.69,162.42) ; TP27.1 v1(400.37,134.23) ; R179.2 v1(312.83,136.14) ; C220.2 v1(133.82,149.86) ; R538.2 v1(84.96,37.97) ; R439.2 v1(397.77,105.41) ; R297.2 v1(148.07,109.42) ; v1(391.54,118.24) v1(392.18,118.24) v1(392.18,117.6) ; v1(391.54,118.24) v1(391.54,117.6) ; v1(391.54,118.24) 390.28,118.24 C305.2 ; C72.2 v1(240.9,99.06) ; U44.9 v1(333.02,24.55) ; C108.2 v1(219.98,112.39) ; C37.2 v1(125.95,21.27) ; C387.2 v1(34.57,27.73) ; U43.16 v1(356.01,24.55) ; C89.2 v1(306.98,127.51) ; v1(89.54,22.53) C276.2 C274.2 89.28,24.65 U41.13 ; C249.2 v1(80.64,131.67) ; R237.2 v1(216.73,163.58) ; R181.2 v1(294.46,163.58) ; C93.2 v1(297.2,116.33) ; R295.2 v1(148.07,135.32) ; U44.16 v1(341.91,24.55) ; C248.2 v1(80.64,132.64) ; R238.2 v1(197.68,163.58) ; C360.2 v1(233.2,24.07) ; C342.2 v1(214.19,21.85) ; R443.2 v1(399.79,105.41) ; R431.2 v1(260.1,104.26) ; R300.2 v1(148.07,120.35) ; R28.2 v1(280.8,89.02) ; C294.2 v1(391.52,152.78) ; v1(18.14,23.11) v1(18.03,23.11) C377.2 ; R29.2 v1(283.34,89.02) ; R107.1 v1(254.83,45.09) ; C338.2 v1(206.76,25.67) ; C178.2 v1(100.08,111.23) ; R550.2 v1(231.74,28.75) ; TP29.1 v1(400.37,156.96) ; C79.2 v1(296.29,117.11) ; C361.2 v1(233.2,23.05) ; C204.2 v1(135.51,114.4) ; C63.2 v1(274.03,21.27) ; C247.2 v1(80.64,140.31) ; C326.2 v1(208.26,38.04) ; C250.2 v1(80.64,124) ; R313.2 v1(138.81,162.42) ; U42.13 75.18,24.65 C275.2 C277.2 v1(75.45,22.53) ; R278.2 v1(119.89,115.7) ; C173.2 v1(123.2,105.67) ; R327.2 v1(78.36,162.42) ; R125.2 v1(229.74,107.18) ; R483.2 v1(225.3,14.16) ; C374.2 v1(18.14,21.34) ; C341.2 v1(221.47,7.81) ; C107.2 v1(304.79,125.2) ; C343.2 v1(221.95,6.54) ; C198.2 98.69,119.51 98.93,119.76 v1(99.05,119.76) ; R453.2 v1(399.79,128.27) ; R264.2 v1(192.38,136.14) ; R346.2 v1(68.08,118.05) ; C76.2 185.93,129.47 ; C140.2 v1(227.97,144.45) ; U28.4 v1(217.07,149.48) ; R314.2 v1(136.51,162.42) ; C344.2 v1(225.28,13.02) ; C104.2 v1(216.03,128.18) ; R312.2 v1(110.6,162.42) ; U22.4 v1(334.42,149.48) ; U42.9 v1(70.1,24.57) ; C96.2 v1(218.44,126.6) ; C256.2 v1(80.64,115.37) ; C376.2 v1(8.15,24.89) ; C179.2 v1(102.36,111.23) ; C384.2 v1(37.34,15.14) ; R153.2 v1(334.08,163.58) ; v1(92.08,39.78) C272.2 C270.2 v1(92.08,37.26) 91.82,37 U41.2 ; R266.2 v1(128.14,99.87) ; S2.3 v1(228.97,84.69) ; U73.3 v1(394.91,25.5) ; R134.2 v1(215.64,120.02) ; R309.2 v1(121.54,162.42) ; P31.12 v1(382.27,86.12) ; R75.1 v1(127.83,45.09) ; R523.2 v1(203.7,72.77) ; C154.2 v1(188.35,144.45) ; v1(352.46,22.5) C287.2 C285.2 352.2,24.62 U43.13 ; R209.2 v1(256.36,163.58) ; C90.2 v1(229.26,127.51) ; C111.2 v1(324.75,144.45) ; v1(258.58,51.24) R93.1 R91.1 ; R330.2 v1(101.96,162.42) ; R438.2 v1(397.77,151) ; R133.2 v1(293.37,120.02) ; R384.1 v1(226.07,39.29) ; R338.2 v1(68.08,135.32) ; U41.9 v1(84.2,24.57) ; C168.2 v1(111.96,102.32) ; R208.2 v1(270.1,136.14) ; R316.2 v1(127.87,162.42) ; R23.2 v1(153.8,89.02) ; R459.1 v1(367.41,171.45) ; R345.2 v1(68.08,120.35) ; R182.2 v1(275.41,163.58) ; C234.2 v1(73.37,149.86) ; v1(391.54,163.83) v1(391.54,163.2) ; R282.2 v1(119.89,117.47) ; C91.2 v1(304.06,110.62) ; C11.2 v1(262.25,117.38) ; R233.2 v1(254.15,136.14) ; R331.2 v1(95.63,162.42) ; R348.2 v1(68.08,109.42) ; P34.3 v1(193.29,7.28) ; R357.2 v1(68.83,24.63) ; R569.2 v1(408.61,20.37) ; P34.5 v1(194.56,7.28) ; P30.12 v1(66.93,86.12) ; C301.2 v1(402.53,149.5) ; R567.2 v1(25.6,14.91) ; R572.2 v1(393.26,14.91) ; R177.2 v1(331.88,136.14) ; R564.2 v1(40.94,20.37) ; R356.2 v1(82.93,24.63) ; R365.2 v1(331.75,24.61) ; R183.2 v1(286.95,163.58) ; C172.2 v1(111.96,105.67) ; C153.2 v1(207.4,144.45) ; C217.2 v1(115.58,149.86) ; U43.2 354.74,36.97 v1(355,37.24) C281.2 C283.2 v1(355,39.75) ; C392.2 v1(405,15.14) ; R234.2 v1(251.05,136.14) ; R364.2 v1(345.85,24.61) ; C258.2 v1(80.64,106.73) ; C86.2 v1(219.48,116.33) ; C323.2 209.92,16.9 ; C323.2 210.47,16.32 ; A1.2 v1(290.04,123.95) ; C238.2 v1(90.64,149.86) ; C216.2 v1(116.55,149.86) ; C183.2 v1(113.16,133.58) ; R449.2 v1(127.07,90.61) ; R557.2 v1(333.78,37.95) ; R262.2 v1(211.43,136.14) ; C318.2 390.28,184.28 v1(391.54,184.28) ; R298.2 v1(148.07,111.72) ; U42.2 77.72,37 v1(77.99,37.26) C271.2 C273.2 v1(77.99,39.78) ; R184.2 v1(267.9,163.58) ; C82.2 v1(216.92,115.8) ; C233.2 v1(81.04,149.86) ; C192.2 v1(119.74,126.62) ; C265.2 v1(219.98,110.62) ; v1(391.54,184.28) v1(392.18,184.28) v1(392.18,183.64) ; v1(391.54,184.28) v1(391.54,183.64) ; R154.2 v1(315.03,163.58) ; C80.2 v1(218.57,117.11) ; C9.2 v1(214.27,62.92) ; C231.2 v1(89.68,149.86) ; R479.2 v1(204.92,12.13) ; C66.2 v1(252.95,21.27) ; R99.1 v1(260.6,56.9) ; C236.2 v1(99.28,149.86) ; Y6.2 216.26,17.39 ; P30.8 v1(69.47,86.12) ; R542.2 v1(70.86,37.97) ; U43.8 v1(347.12,37.63) ; R385.1 v1(234.45,39.29) ; C175.2 v1(95.14,117.75) ; R239.2 v1(209.22,163.58) ; C99.2 v1(294.64,128.17) ; R296.2 v1(148.07,137.63) ; R422.2 v1(27.56,99.18) ; R149.2 v1(292.99,117.09) ; R299.2 v1(148.07,118.05) ; R137.2 v1(304.56,113.79) ; U70.5 v1(40.09,27.79) ; C78.2 v1(226.33,112.27) ; C300.2 v1(402.53,103.91) ; C353.2 v1(194.8,26.86) ; DS21.C v1(61.7,89.88) ; R427.2 v1(254,104.26) ; C398.2 v1(402.23,27.73) ; C194.2 v1(96.41,126.62) ; C112.2 v1(305.7,144.45) ; C125.2 v1(285.12,144.45) ; U71.3 v1(27.24,25.5) ; C310.2 v1(391.52,173.23) ; R590.2 v1(150.06,92.01) ; R329.2 v1(104.26,162.42) ; R325.2 v1(86.99,162.42) ; R212.2 v1(229.8,163.58) ; C237.2 v1(98.31,149.86) ; U44.13 338.1,24.62 C284.2 C286.2 v1(338.36,22.5) ; R67.1 v1(133.6,56.9) ; R424.2 v1(30.61,99.18) ; C215.2 v1(124.22,149.86) ; U29.4 v1(198.02,149.48) ; C356.2 v1(230.16,6.22) ; R85.1 v1(263.14,56.9) ; C206.2 v1(135.51,123.04) ; R87.1 v1(264.41,56.9) ; C181.2 v1(114.81,133.58) ; C98.2 v1(227.07,125.2) ; R537.2 v1(87.5,37.97) ; R310.2 v1(119.23,162.42) ; C139.2 v1(247.02,144.45) ; C12.2 v1(35.43,112.3) ; R423.2 v1(29.08,99.18) ; R430.2 v1(258.57,104.26) ; R150.2 v1(215.26,117.09) ; R426.2 v1(252.48,104.26) ; R139.2 v1(305.7,113.79) ; R283.2 v1(119.89,118.62) ; R339.2 v1(68.08,128.99) ; C362.2 v1(233.2,22.03) ; R121.2 v1(241.56,97.54) ; C110.2 v1(207.8,123.94) ; U25.4 v1(275.74,149.48) ; C368.2 v1(210.67,35.87) ; C313.2 v1(402.53,126.77) ; C170.2 v1(123.2,102.32) ; R315.2 v1(130.17,162.42) ; R205.2 v1(292.25,136.14) ; R294.2 v1(148.07,128.99) ; C197.2 v1(105.28,111.35) ; R236.2 v1(232,136.14) ; R59.1 R61.1 v1(131.58,51.24) ; DS22.C v1(377.04,89.88) ; C367.2 v1(210.67,32.84) ; R428.2 v1(255.52,104.26) ; R421.2 v1(26.04,99.18) ; C222.2 v1(125.19,149.86) ; U43.9 v1(347.12,24.55) ; R553.2 v1(347.87,37.95) ; R457.2 v1(254.07,89.09) ; C191.2 v1(117.86,132.41) ; C67.2 v1(252.95,23.81) ; R332.2 v1(93.33,162.42) ; C8.2 v1(140.08,91.91) ; R206.2 v1(289.15,136.14) ; R420.2 v1(24.51,99.18) ; C92.2 v1(226.33,110.62) ; R26.2 v1(156.34,89.02) ; R491.2 v1(197.1,47.56) ; R77.1 v1(127.83,44.01) ; U23.4 v1(315.37,149.48) ; C381.2 v1(375.81,24.89) ; R448.2 v1(397.77,171.45) ; C218.2 v1(107.92,149.86) ; U41.8 v1(84.2,37.66) ; C396.2 v1(235.12,30.66) ; R454.2 v1(399.79,171.45) ; C309.2 v1(391.52,130.05) ; R340.2 v1(68.08,126.69) ; R337.2 v1(68.08,137.63) ; U26.4 v1(256.69,149.48) ; C10.2 v1(34.29,112.3) ; R458.2 v1(254.07,90.61) ; C314.2 v1(402.53,169.95) ; C296.2 v1(391.52,107.19) ; R30.2 v1(285.88,89.02) ; C103.2 v1(293.75,128.18) ; C393.2 v1(398.27,24.49) ; R72.1 v1(134.87,56.9) ; U72.5 v1(407.76,27.79) ; C23.2 v1(212.34,90.68) ; C263.2 v1(297.71,110.62) ; C322.2 v1(201.54,28.11) ; C77.2 v1(304.06,112.27) ; R180.2 v1(309.73,136.14) ; C255.2 v1(80.64,123.04) ; C369.2 v1(385.81,23.11) ; R425.2 v1(32.13,99.18) ; C73.2 v1(240.9,84.45) ; R293.2 v1(148.07,126.69) ; R207.2 v1(273.2,136.14) ; C380.2 v1(385.81,21.34) ; C200.2 v1(135.51,131.67) ; R545.2 v1(350.41,37.95) ; R261.2 v1(214.53,136.14) ; R347.2 v1(68.08,111.72) ; R522.2 v1(241.56,90.04) ; C126.2 v1(266.07,144.45) ; R263.2 v1(195.48,136.14) ; R450.2 v1(127.07,89.09) ; C97.2 v1(297.71,112.39) ; C201.2 v1(135.51,132.64) ; R240.2 v1(190.17,163.58) ; C109.2 v1(285.52,123.94) ; v1(132.86,149.86) C221.2 ; C40.2 v1(147.03,23.81) ; R541.2 v1(73.4,37.97) ; TP26.1 v1(400.37,177.41) ; R210.2 v1(237.31,163.58) ; C65.2 v1(274.03,23.81) ; C363.2 v1(217.62,23.94) ; R155.2 v1(326.57,163.58) ; U27.4 v1(237.64,149.48)
  TOP w1.016: 328.89,192.69 P7.2 ; P7.2 330.45,191.13 ; P7.2 332.02,192.69 ; P7.3 327.32,189.69 ; P7.3 324.19,189.69 ; P7.3 325.75,188.13 ; P7.3 325.75,191.25
  L2_GND w0.508: 365.85,77.09 P40.16 ; P40.16 367.03,78.27 ; P40.16 367.03,75.91 ; P40.16 368.21,77.09 ; 47.08,59.31 P20.12 ; P20.12 48.26,58.13 ; P20.12 48.26,60.49 ; P20.12 49.44,59.31 ; 156.84,186.94 P12.1 ; P12.1 156.84,189.18 ; P12.1 155.73,188.06 ; P12.1 157.96,188.06 ; 14.6,85.18 P32.5 ; P32.5 15.79,86.36 ; P32.5 14.6,87.54 ; P32.5 13.42,86.36 ; P18.2_5 70.84,18.92 ; P18.2_5 69.6,17.68 ; P18.2_5 72.09,17.68 ; P18.2_5 70.84,16.43 ; 363.6,68.29 P39.8 ; P39.8 363.6,70.65 ; P39.8 362.42,69.47 ; P39.8 364.78,69.47 ; P33.5 331.13,86.36 ; P33.5 329.95,87.54 ; P33.5 329.95,85.18 ; P33.5 328.76,86.36 ; 324.87,85.18 P33.9 ; P33.9 326.05,86.36 ; P33.9 324.87,87.54 ; P33.9 323.68,86.36 ; P15.GND1 226.39,193.63 ; P15.GND1 226.39,190.1 ; P15.GND1 228.15,191.86 ; P15.GND1 224.62,191.86 ; P19.2_6 343.45,16.05 ; P19.2_6 343.45,13.56 ; P19.2_6 342.2,14.81 ; P19.2_6 344.69,14.81 ; 362.42,84.71 P39.2 ; P39.2 363.6,83.53 ; P39.2 364.78,84.71 ; P39.2 363.6,85.89 ; 71.32,184.68 P14.8A ; P14.8A 70.08,185.93 ; P14.8A 71.32,187.17 ; P14.8A 72.57,185.93 ; 75.48,187.53 P14.22A ; P14.22A 74.23,188.77 ; P14.22A 75.48,190.02 ; P14.22A 76.72,188.77 ; P14.25B 83.78,183.26 ; P14.25B 85.03,182.02 ; P14.25B 82.54,182.02 ; P14.25B 83.78,180.77 ; 202.52,8.18 P9.SH1 ; P9.SH1 203.38,7.02 ; P9.SH1 204.23,8.18 ; P9.SH1 203.38,9.34 ; P27.1 322.33,111.04 ; P27.1 321.14,109.86 ; P27.1 323.51,109.86 ; P27.1 322.33,108.67 ; P20.20 49.44,38.99 ; P20.20 47.08,38.99 ; P20.20 48.26,37.81 ; P20.20 48.26,40.17 ; 47.08,69.47 P20.8 ; P20.8 49.44,69.47 ; P20.8 48.26,70.65 ; P20.8 48.26,68.29 ; 144.36,103 P5.2 ; P5.2 145.54,104.18 ; P5.2 145.54,101.82 ; P5.2 146.72,103 ; 99.78,45.72 P37.11 ; P37.11 100.97,46.9 ; P37.11 100.97,44.54 ; P37.11 102.15,45.72 ; 70.84,9.68 P18.1_5 ; P18.1_5 69.6,10.92 ; P18.1_5 72.09,10.92 ; P18.1_5 70.84,12.17 ; 5.8,86.36 P32.11 ; P32.11 8.17,86.36 ; P32.11 6.98,87.54 ; P32.11 6.98,85.18 ; 220.34,186.94 P15.1 ; P15.1 219.23,188.06 ; P15.1 220.34,189.18 ; P15.1 221.46,188.06 ; 47.08,74.55 P20.6 ; P20.6 48.26,75.73 ; P20.6 48.26,73.37 ; P20.6 49.44,74.55 ; 162.14,103 P5.16 ; P5.16 164.5,103 ; P5.16 163.32,104.18 ; P5.16 163.32,101.82 ; 129.37,191.86 P11.GND1 ; P11.GND1 131.14,190.1 ; P11.GND1 132.9,191.86 ; P11.GND1 131.14,193.63 ; 92.05,186.64 P14.SH4 ; P14.SH4 92.05,190.91 ; P14.SH4 94.18,188.77 ; P14.SH4 89.92,188.77 ; P20.14 49.44,54.23 ; P20.14 47.08,54.23 ; P20.14 48.26,53.05 ; P20.14 48.26,55.41 ; P14.8B 71.32,180.42 ; P14.8B 72.57,179.17 ; P14.8B 70.08,179.17 ; P14.8B 71.32,177.93 ; P18.1_6 80.53,9.32 ; P18.1_6 79.29,8.08 ; P18.1_6 80.53,6.83 ; P18.1_6 81.78,8.08 ; P16.25 287.64,182.14 ; P16.25 287.64,180.03 ; P16.25 286.59,181.09 ; P16.25 288.7,181.09 ; P15.GND3 226.39,182.33 ; P15.GND3 224.62,180.56 ; P15.GND3 228.15,180.56 ; P15.GND3 226.39,178.8 ; P6.6 278.8,103 ; P6.6 277.62,101.82 ; P6.6 276.44,103 ; P6.6 277.62,104.18 ; 278.98,103 P6.8 ; P6.8 280.16,101.82 ; P6.8 280.16,104.18 ; P6.8 281.34,103 ; P13.GND2 182.55,193.63 ; P13.GND2 182.55,190.1 ; P13.GND2 180.79,191.86 ; P13.GND2 184.32,191.86 ; P33.11 322.33,87.54 ; P33.11 322.33,85.18 ; P33.11 323.51,86.36 ; P33.11 321.14,86.36 ; P14.SH3 92.05,182.91 ; P14.SH3 92.05,178.64 ; P14.SH3 94.18,180.77 ; P14.SH3 89.92,180.77 ; P21.6 52.87,51.69 ; P21.6 51.69,52.87 ; P21.6 50.51,51.69 ; P21.6 51.69,50.51 ; 99.78,48.26 P37.12 ; P37.12 102.15,48.26 ; P37.12 100.97,47.08 ; P37.12 100.97,49.44 ; 47.08,44.07 P20.18 ; P20.18 48.26,42.89 ; P20.18 49.44,44.07 ; P20.18 48.26,45.25 ; 363.6,53.05 P39.14 ; P39.14 364.78,54.23 ; P39.14 362.42,54.23 ; P39.14 363.6,55.41 ; 13.97,9.78 M1.2 ; M1.2 13.97,12.01 ; M1.2 12.85,10.9 ; M1.2 15.09,10.9 ; P14.5B 63.02,180.42 ; P14.5B 63.02,177.93 ; P14.5B 61.77,179.17 ; P14.5B 64.26,179.17 ; P14.2B 54.71,180.42 ; P14.2B 55.96,179.17 ; P14.2B 53.47,179.17 ; P14.2B 54.71,177.93 ; P16.19 272.14,181.09 ; P16.19 271.08,182.14 ; P16.19 271.08,180.03 ; P16.19 270.03,181.09 ; 198.49,79.31 P35.19 199.42,80.24 ; 131.14,178.8 P11.GND3 ; P11.GND3 131.14,182.33 ; P11.GND3 129.37,180.56 ; P11.GND3 132.9,180.56 ; 381.63,9.78 M2.2 ; M2.2 380.52,10.9 ; M2.2 382.75,10.9 ; M2.2 381.63,12.01 ; P21.4 52.87,46.61 ; P21.4 51.69,45.43 ; P21.4 51.69,47.79 ; P21.4 50.51,46.61 ; 67.17,180.77 P14.19B ; P14.19B 65.93,182.02 ; P14.19B 67.17,183.26 ; P14.19B 68.42,182.02 ; 289.14,103 P6.16 ; P6.16 291.5,103 ; P6.16 290.32,101.82 ; P6.16 290.32,104.18 ; 367.03,65.75 P40.12 ; P40.12 368.21,66.93 ; P40.12 367.03,68.11 ; P40.12 365.85,66.93 ; P5.12 158.24,104.18 ; P5.12 157.06,103 ; P5.12 158.24,101.82 ; P5.12 159.42,103 ; P13.GND3 196.4,180.56 ; P13.GND3 194.64,182.33 ; P13.GND3 192.87,180.56 ; P13.GND3 194.64,178.8 ; P12.GND4 150.8,182.33 ; P12.GND4 149.04,180.56 ; P12.GND4 150.8,178.8 ; P12.GND4 152.57,180.56 ; P40.20 367.03,88.43 ; P40.20 368.21,87.25 ; P40.20 365.85,87.25 ; P40.20 367.03,86.07 ; P32.9 9.53,87.54 ; P32.9 8.34,86.36 ; P32.9 9.53,85.18 ; P32.9 10.71,86.36 ; M2.6 385.29,15.9 ; M2.6 384.18,17.01 ; M2.6 383.06,15.9 ; M2.6 384.18,14.78 ; P16.8 275.22,179.3 ; P16.8 276.28,178.24 ; P16.8 274.17,178.24 ; P16.8 275.22,177.19 ; 363.6,42.89 P39.18 ; P39.18 364.78,44.07 ; P39.18 362.42,44.07 ; P39.18 363.6,45.25 ; 51.69,75.91 P21.16 ; P21.16 50.51,77.09 ; P21.16 51.69,78.27 ; P21.16 52.87,77.09 ; P40.14 368.21,72.01 ; P40.14 365.85,72.01 ; P40.14 367.03,73.19 ; P40.14 367.03,70.83 ; 123.98,188.06 P11.1 ; P11.1 125.09,189.18 ; P11.1 126.21,188.06 ; P11.1 125.09,186.94 ; 261.75,181.09 P16.16 ; P16.16 263.86,181.09 ; P16.16 262.8,180.03 ; P16.16 262.8,182.14 ; P9.GND1 205.65,10.02 ; 79.29,14.83 P18.2_6 ; P18.2_6 80.53,13.59 ; P18.2_6 81.78,14.83 ; P18.2_6 80.53,16.08 ; P13.GND4 182.55,182.33 ; P13.GND4 184.32,180.56 ; P13.GND4 180.79,180.56 ; P13.GND4 182.55,178.8 ; 367.03,45.43 P40.4 ; P40.4 368.21,46.61 ; P40.4 365.85,46.61 ; P40.4 367.03,47.79 ; P6.4 275.08,104.18 ; P6.4 276.26,103 ; P6.4 275.08,101.82 ; P6.4 273.9,103 ; 78.38,185.93 P14.11A ; P14.11A 80.87,185.93 ; P14.11A 79.63,184.68 ; P14.11A 79.63,187.17 ; 362.42,49.15 P39.16 ; P39.16 364.78,49.15 ; P39.16 363.6,47.97 ; P39.16 363.6,50.33 ; P35.3 209.58,80.24 ; P12.GND2 150.8,193.63 ; P12.GND2 149.04,191.86 ; P12.GND2 150.8,190.1 ; P12.GND2 152.57,191.86 ; P39.20 364.78,38.99 ; P39.20 363.6,37.81 ; P39.20 363.6,40.17 ; P39.20 362.42,38.99 ; P37.1 88.27,46.9 ; P37.1 87.08,45.72 ; P37.1 88.27,44.54 ; P37.1 89.45,45.72 ; P40.2 367.03,42.71 ; P40.2 368.21,41.53 ; P40.2 367.03,40.35 ; P40.2 365.85,41.53 ; P39.6 363.6,75.73 ; P39.6 364.78,74.55 ; P39.6 362.42,74.55 ; P39.6 363.6,73.37 ; P14.SH2 47.19,180.77 ; P14.SH2 45.06,182.91 ; P14.SH2 42.93,180.77 ; P14.SH2 45.06,178.64 ; P16.2 258.66,179.3 ; P16.2 259.72,178.24 ; P16.2 258.66,177.19 ; P16.2 257.61,178.24 ; 363.6,78.45 P39.4 ; P39.4 364.78,79.63 ; P39.4 362.42,79.63 ; P39.4 363.6,80.81 ; 57.62,182.02 P14.16B ; P14.16B 58.86,183.26 ; P14.16B 58.86,180.77 ; P14.16B 60.11,182.02 ; 151.98,103 P5.8 ; P5.8 154.34,103 ; P5.8 153.16,101.82 ; P5.8 153.16,104.18 ; 75.13,17.68 P18.2_3 ; P18.2_3 76.38,16.43 ; P18.2_3 76.38,18.92 ; P18.2_3 77.62,17.68 ; 211.13,9.33 P9.B1 210.45,10.02 ; 214.3,190.1 P15.GND2 ; P15.GND2 212.54,191.86 ; P15.GND2 216.07,191.86 ; P15.GND2 214.3,193.63 ; 281.52,103 P6.10 ; P6.10 282.7,101.82 ; P6.10 283.88,103 ; P6.10 282.7,104.18 ; 326.22,86.36 P33.7 ; P33.7 327.41,85.18 ; P33.7 327.41,87.54 ; P33.7 328.59,86.36 ; P12.GND1 162.89,193.63 ; P12.GND1 161.12,191.86 ; P12.GND1 162.89,190.1 ; P12.GND1 164.65,191.86 ; P12.GND3 164.65,180.56 ; P12.GND3 162.89,182.33 ; P12.GND3 161.12,180.56 ; P12.GND3 162.89,178.8 ; 365.85,56.77 P40.8 ; P40.8 367.03,57.95 ; P40.8 367.03,55.59 ; P40.8 368.21,56.77 ; 402.46,3.89 J2.S ; J2.S 402.46,6.63 ; J2.S 401.09,5.26 ; J2.S 403.84,5.26 ; 63.02,184.68 P14.5A ; P14.5A 63.02,187.17 ; P14.5A 64.26,185.93 ; P14.5A 61.77,185.93 ; P14.SH1 47.19,188.77 ; P14.SH1 45.06,186.64 ; P14.SH1 45.06,190.91 ; P14.SH1 42.93,188.77 ; P14.16A 60.11,188.77 ; P14.16A 58.86,190.02 ; P14.16A 57.62,188.77 ; P14.16A 58.86,187.53 ; P19.1_6 343.45,9.3 ; P19.1_6 343.45,6.81 ; P19.1_6 344.69,8.05 ; P19.1_6 342.2,8.05 ; P9.SH2 211.91,9.34 ; P9.SH2 211.06,8.18 ; P9.SH2 211.91,7.02 ; P9.SH2 212.77,8.18 ; 367.03,50.51 P40.6 ; P40.6 365.85,51.69 ; P40.6 367.03,52.87 ; P40.6 368.21,51.69 ; P20.4 49.44,79.63 ; P20.4 47.08,79.63 ; P20.4 48.26,80.81 ; P20.4 48.26,78.45 ; P19.2_3 340.54,17.65 ; P19.2_3 338.05,17.65 ; P19.2_3 339.29,18.9 ; P19.2_3 339.29,16.41 ; 10.88,86.36 P32.7 ; P32.7 12.06,87.54 ; P32.7 12.06,85.18 ; P32.7 13.25,86.36 ; P11.GND4 120.82,180.56 ; P11.GND4 119.05,178.8 ; P11.GND4 117.29,180.56 ; P11.GND4 119.05,182.33 ; 149.44,103 P5.6 ; P5.6 151.8,103 ; P5.6 150.62,101.82 ; P5.6 150.62,104.18 ; P39.12 364.78,59.31 ; P39.12 363.6,60.49 ; P39.12 363.6,58.13 ; P39.12 362.42,59.31 ; P9.SH4 203.38,4.61 ; P9.SH4 204.23,3.45 ; P9.SH4 202.52,3.45 ; 51.69,60.67 P21.10 ; P21.10 51.69,63.03 ; P21.10 50.51,61.85 ; P21.10 52.87,61.85 ; P21.2 52.87,41.53 ; P21.2 51.69,42.71 ; P21.2 51.69,40.35 ; P21.2 50.51,41.53 ; 211.06,3.45 P9.SH3 ; P9.SH3 211.91,4.61 ; P9.SH3 212.77,3.45 ; P14.19A 67.17,190.02 ; P14.19A 67.17,187.53 ; P14.19A 65.93,188.77 ; P14.19A 68.42,188.77 ; 34.8,3.89 J1.S ; J1.S 36.17,5.26 ; J1.S 34.8,6.63 ; J1.S 33.43,5.26 ; P21.8 51.69,57.95 ; P21.8 51.69,55.59 ; P21.8 50.51,56.77 ; P21.8 52.87,56.77 ; 214.3,178.8 P15.GND4 ; P15.GND4 216.07,180.56 ; P15.GND4 212.54,180.56 ; P15.GND4 214.3,182.33 ; 82.54,188.77 P14.25A ; P14.25A 83.78,187.53 ; P14.25A 85.03,188.77 ; P14.25A 83.78,190.02 ; 332.51,17.65 P19.2_5 ; P19.2_5 333.76,16.41 ; P19.2_5 335,17.65 ; P19.2_5 333.76,18.9 ; 367.03,60.67 P40.10 ; P40.10 367.03,63.03 ; P40.10 368.21,61.85 ; P40.10 365.85,61.85 ; P20.16 48.26,50.33 ; P20.16 48.26,47.97 ; P20.16 47.08,49.15 ; P20.16 49.44,49.15 ; P35.15 201.96,80.24 ; 51.69,65.75 P21.12 ; P21.12 50.51,66.93 ; P21.12 51.69,68.11 ; P21.12 52.87,66.93 ; P6.14 288.96,103 ; P6.14 286.6,103 ; P6.14 287.78,104.18 ; P6.14 287.78,101.82 ; 285.24,101.82 P6.12 ; P6.12 284.06,103 ; P6.12 285.24,104.18 ; P6.12 286.42,103 ; 321.14,101.98 P23.1 ; P23.1 322.33,103.16 ; P23.1 322.33,100.8 ; P23.1 323.51,101.98 ; 54.71,184.68 P14.2A ; P14.2A 54.71,187.17 ; P14.2A 53.47,185.93 ; P14.2A 55.96,185.93 ; 50.51,72.01 P21.14 ; P21.14 52.87,72.01 ; P21.14 51.69,70.83 ; P21.14 51.69,73.19 ; P22.1 179.62,101.98 ; P22.1 178.43,103.16 ; P22.1 178.43,100.8 ; P22.1 177.25,101.98 ; P21.20 52.87,87.25 ; P21.20 50.51,87.25 ; P21.20 51.69,88.43 ; P21.20 51.69,86.07 ; P40.18 368.21,82.17 ; P40.18 365.85,82.17 ; P40.18 367.03,83.35 ; P40.18 367.03,80.99 ; P16.22 279.36,182.14 ; P16.22 280.42,181.09 ; P16.22 279.36,180.03 ; P16.22 278.31,181.09 ; P19.1_3 339.29,12.14 ; P19.1_3 339.29,9.65 ; P19.1_3 338.05,10.9 ; P19.1_3 340.54,10.9 ; P14.11B 80.87,179.17 ; P14.11B 79.63,180.42 ; P14.11B 78.38,179.17 ; P14.11B 79.63,177.93 ; 47.08,64.39 P20.10 ; P20.10 49.44,64.39 ; P20.10 48.26,65.57 ; P20.10 48.26,63.21 ; 75.13,10.92 P18.1_3 ; P18.1_3 76.38,9.68 ; P18.1_3 76.38,12.17 ; P18.1_3 77.62,10.92 ; 88.27,47.08 P37.2 ; P37.2 88.27,49.44 ; P37.2 89.45,48.26 ; P37.2 87.08,48.26 ; P20.2 49.44,84.71 ; P20.2 47.08,84.71 ; P20.2 48.26,85.89 ; P20.2 48.26,83.53 ; P5.10 155.7,104.18 ; P5.10 156.88,103 ; P5.10 155.7,101.82 ; P5.10 154.52,103 ; P16.11 283.5,179.3 ; P16.11 282.45,178.24 ; P16.11 284.56,178.24 ; P16.11 283.5,177.19 ; 188.59,186.94 P13.1 ; P13.1 189.71,188.06 ; P13.1 187.48,188.06 ; P13.1 188.59,189.18 ; 266.94,177.19 P16.5 ; P16.5 265.89,178.24 ; P16.5 268,178.24 ; P16.5 266.94,179.3 ; M1.6 17.63,15.9 ; M1.6 15.39,15.9 ; M1.6 16.51,17.01 ; M1.6 16.51,14.78 ; P26.1 178.43,111.04 ; P26.1 178.43,108.67 ; P26.1 179.62,109.86 ; P26.1 177.25,109.86 ; 272.54,101.82 P6.2 ; P6.2 272.54,104.18 ; P6.2 273.72,103 ; P6.2 271.36,103 ; 363.6,63.21 P39.10 ; P39.10 363.6,65.57 ; P39.10 362.42,64.39 ; P39.10 364.78,64.39 ; P14.22B 76.72,182.02 ; P14.22B 75.48,180.77 ; P14.22B 75.48,183.26 ; P14.22B 74.23,182.02 ; P25.1 322.33,95.29 ; P25.1 322.33,92.93 ; P25.1 323.51,94.11 ; P25.1 321.14,94.11 ; 160.78,101.82 P5.14 ; P5.14 159.6,103 ; P5.14 160.78,104.18 ; P5.14 161.96,103 ; P35.5 208.31,80.24 ; P21.18 52.87,82.17 ; P21.18 50.51,82.17 ; P21.18 51.69,83.35 ; P21.18 51.69,80.99 ; P13.GND1 196.4,191.86 ; P13.GND1 194.64,190.1 ; P13.GND1 192.87,191.86 ; P13.GND1 194.64,193.63 ; P5.4 149.26,103 ; P5.4 148.08,101.82 ; P5.4 148.08,104.18 ; P5.4 146.9,103 ; P24.1 178.43,95.29 ; P24.1 178.43,92.93 ; P24.1 177.25,94.11 ; P24.1 179.62,94.11 ; P19.1_5 333.76,12.14 ; P19.1_5 333.76,9.65 ; P19.1_5 335,10.9 ; P19.1_5 332.51,10.9 ; P11.GND2 119.05,193.63 ; P11.GND2 117.29,191.86 ; P11.GND2 120.82,191.86 ; P11.GND2 119.05,190.1 ; 204.84,10.02 P9.B12 204.16,9.33 ; P9.GND2 209.64,10.02 ; P35.17 200.69,80.24
  L2_GND w1.016: 325.75,188.13 P7.3 ; P7.3 327.32,189.69 ; P7.3 325.75,191.25 ; P7.3 324.19,189.69 ; P7.2 332.02,192.69 ; P7.2 330.45,191.13 ; P7.2 328.89,192.69
  L3_SIG w0.508: 50.51,72.01 P21.14 ; P21.14 51.69,70.83 ; P21.14 51.69,73.19 ; P21.14 52.87,72.01 ; P24.1 179.62,94.11 ; P24.1 177.25,94.11 ; P24.1 178.43,95.29 ; 342.2,8.05 P19.1_6 ; P19.1_6 343.45,9.3 ; P19.1_6 343.45,6.81 ; P19.1_6 344.69,8.05 ; P15.GND4 216.07,180.56 ; P15.GND4 214.3,178.8 ; P15.GND4 212.54,180.56 ; P5.14 161.96,103 ; P5.14 160.78,104.18 ; P5.14 160.78,101.82 ; P5.14 159.6,103 ; 194.64,178.8 P13.GND3 ; P13.GND3 192.87,180.56 ; P13.GND3 194.64,182.33 ; 157.06,103 P5.12 ; P5.12 159.42,103 ; P5.12 158.24,101.82 ; P5.12 158.24,104.18 ; P14.2A 54.71,187.17 ; P14.2A 55.96,185.93 ; P14.2A 53.47,185.93 ; P14.2A 54.71,184.68 ; P9.SH4 204.23,3.45 ; P9.SH4 202.52,3.45 ; P9.SH4 203.38,4.61 ; 271.08,180.03 P16.19 ; P16.19 272.14,181.09 ; P16.19 271.08,182.14 ; 80.53,6.83 P18.1_6 ; P18.1_6 81.78,8.08 ; P18.1_6 79.29,8.08 ; P18.1_6 80.53,9.32 ; 50.51,56.77 P21.8 ; P21.8 52.87,56.77 ; P21.8 51.69,57.95 ; P21.8 51.69,55.59 ; 178.43,108.67 P26.1 ; P26.1 177.25,109.86 ; P26.1 178.43,111.04 ; P26.1 179.62,109.86 ; 276.44,103 P6.6 ; P6.6 277.62,104.18 ; P6.6 278.8,103 ; 162.89,190.1 P12.GND1 ; P12.GND1 162.89,193.63 ; P12.GND1 164.65,191.86 ; P12.GND1 161.12,191.86 ; 162.89,178.8 P12.GND3 ; P12.GND3 161.12,180.56 ; P12.GND3 162.89,182.33 ; P12.GND3 164.65,180.56 ; 63.02,184.68 P14.5A ; P14.5A 63.02,187.17 ; P14.5A 61.77,185.93 ; P14.5A 64.26,185.93 ; P39.18 364.78,44.07 ; P39.18 363.6,42.89 ; P39.18 363.6,45.25 ; P39.18 362.42,44.07 ; P37.2 89.45,48.26 ; P37.2 88.27,47.08 ; P37.2 87.08,48.26 ; P37.2 88.27,49.44 ; 50.51,77.09 P21.16 ; P21.16 51.69,75.91 ; P21.16 51.69,78.27 ; P21.16 52.87,77.09 ; P39.4 364.78,79.63 ; P39.4 362.42,79.63 ; P39.4 363.6,78.45 ; 332.51,17.65 P19.2_5 ; P19.2_5 335,17.65 ; P19.2_5 333.76,16.41 ; P19.2_5 333.76,18.9 ; 51.69,80.99 P21.18 ; P21.18 52.87,82.17 ; P21.18 51.69,83.35 ; P21.18 50.51,82.17 ; P32.9 9.53,87.54 ; P32.9 8.34,86.36 ; P32.9 10.71,86.36 ; P32.9 9.53,85.18 ; 16.51,14.78 M1.6 ; M1.6 16.51,17.01 ; M1.6 17.63,15.9 ; M1.6 15.39,15.9 ; 6.98,85.18 P32.11 ; P32.11 8.17,86.36 ; P32.11 5.8,86.36 ; P32.11 6.98,87.54 ; 282.45,178.24 P16.11 ; P16.11 284.56,178.24 ; P16.11 283.5,177.19 ; 365.85,72.01 P40.14 368.21,72.01 ; 368.21,56.77 P40.8 365.85,56.77 ; P12.1 156.84,189.18 ; P12.1 155.73,188.06 ; P12.1 156.84,186.94 ; P12.1 157.96,188.06 ; 51.69,65.75 P21.12 ; P21.12 50.51,66.93 ; P21.12 52.87,66.93 ; P21.12 51.69,68.11 ; M1.2 15.09,10.9 ; M1.2 12.85,10.9 ; M1.2 13.97,12.01 ; M1.2 13.97,9.78 ; 333.76,9.65 P19.1_5 ; P19.1_5 332.51,10.9 ; P19.1_5 335,10.9 ; 273.9,103 P6.4 ; P6.4 276.26,103 ; P6.4 275.08,104.18 ; P15.GND2 216.07,191.86 ; P15.GND2 214.3,193.63 ; P15.GND2 212.54,191.86 ; 50.51,51.69 P21.6 ; P21.6 51.69,52.87 ; P21.6 52.87,51.69 ; P21.6 51.69,50.51 ; 322.33,100.8 P23.1 ; P23.1 321.14,101.98 ; P23.1 322.33,103.16 ; P23.1 323.51,101.98 ; J1.S 34.8,6.63 ; J1.S 33.43,5.26 ; J1.S 34.8,3.89 ; J1.S 36.17,5.26 ; J2.S 403.84,5.26 ; J2.S 402.46,3.89 ; J2.S 401.09,5.26 ; J2.S 402.46,6.63 ; P33.9 326.05,86.36 ; P33.9 324.87,85.18 ; P33.9 323.68,86.36 ; P20.18 48.26,45.25 ; P20.18 49.44,44.07 ; P20.18 47.08,44.07 ; P20.18 48.26,42.89 ; P5.4 148.08,104.18 ; P5.4 148.08,101.82 ; P5.4 149.26,103 ; P5.4 146.9,103 ; 117.29,191.86 P11.GND2 ; P11.GND2 119.05,190.1 ; P11.GND2 120.82,191.86 ; P11.GND2 119.05,193.63 ; 202.52,8.18 P9.SH1 ; P9.SH1 203.38,7.02 ; P9.SH1 204.23,8.18 ; P9.SH1 203.38,9.34 ; P15.GND1 228.15,191.86 ; P15.GND1 226.39,193.63 ; P15.GND1 226.39,190.1 ; P15.GND1 224.62,191.86 ; P13.GND1 196.4,191.86 ; P13.GND1 194.64,193.63 ; P13.GND1 192.87,191.86 ; 219.23,188.06 P15.1 ; P15.1 221.46,188.06 ; P15.1 220.34,186.94 ; P20.4 49.44,79.63 ; P20.4 47.08,79.63 ; P20.4 48.26,80.81 ; P20.4 48.26,78.45 ; P40.2 367.03,42.71 ; P40.2 368.21,41.53 ; P40.2 365.85,41.53 ; P40.2 367.03,40.35 ; P18.1_5 70.84,12.17 ; P18.1_5 72.09,10.92 ; P18.1_5 69.6,10.92 ; P18.1_5 70.84,9.68 ; 45.06,186.64 P14.SH1 ; P14.SH1 42.93,188.77 ; P14.SH1 45.06,190.91 ; P14.SH1 47.19,188.77 ; P6.2 273.72,103 ; P6.2 271.36,103 ; P6.2 272.54,104.18 ; P39.2 363.6,85.89 ; P39.2 364.78,84.71 ; P39.2 362.42,84.71 ; P39.2 363.6,83.53 ; 365.85,87.25 P40.20 ; P40.20 368.21,87.25 ; P40.20 367.03,88.43 ; P40.20 367.03,86.07 ; P6.12 285.24,104.18 ; P6.12 286.42,103 ; P6.12 284.06,103 ; 76.38,9.68 P18.1_3 ; P18.1_3 77.62,10.92 ; P18.1_3 76.38,12.17 ; P18.1_3 75.13,10.92 ; P18.2_3 77.62,17.68 ; P18.2_3 75.13,17.68 ; P18.2_3 76.38,16.43 ; P18.2_3 76.38,18.92 ; 362.42,59.31 P39.12 364.78,59.31 ; 342.2,14.81 P19.2_6 ; P19.2_6 343.45,13.56 ; P19.2_6 344.69,14.81 ; P19.2_6 343.45,16.05 ; 226.39,178.8 P15.GND3 ; P15.GND3 224.62,180.56 ; P15.GND3 226.39,182.33 ; P15.GND3 228.15,180.56 ; P12.GND2 152.57,191.86 ; P12.GND2 150.8,190.1 ; P12.GND2 150.8,193.63 ; P12.GND2 149.04,191.86 ; 144.36,103 P5.2 ; P5.2 146.72,103 ; P5.2 145.54,104.18 ; P5.2 145.54,101.82 ; 51.69,40.35 P21.2 ; P21.2 52.87,41.53 ; P21.2 51.69,42.71 ; P21.2 50.51,41.53 ; 125.09,186.94 P11.1 ; P11.1 125.09,189.18 ; P11.1 123.98,188.06 ; P11.1 126.21,188.06 ; 12.06,85.18 P32.7 ; P32.7 13.25,86.36 ; P32.7 10.88,86.36 ; P32.7 12.06,87.54 ; P20.20 49.44,38.99 ; P20.20 47.08,38.99 ; P20.20 48.26,37.81 ; P20.20 48.26,40.17 ; 322.33,85.18 P33.11 323.51,86.36 ; P20.12 48.26,60.49 ; P20.12 49.44,59.31 ; P20.12 48.26,58.13 ; P20.12 47.08,59.31 ; 381.63,9.78 M2.2 ; M2.2 380.52,10.9 ; M2.2 382.75,10.9 ; M2.2 381.63,12.01 ; P6.8 280.16,104.18 ; P6.8 281.34,103 ; P6.8 278.98,103 ; 47.08,84.71 P20.2 ; P20.2 49.44,84.71 ; P20.2 48.26,83.53 ; P20.2 48.26,85.89 ; P6.10 282.7,104.18 ; P6.10 281.52,103 ; P6.10 283.88,103 ; P6.16 290.32,104.18 ; P6.16 289.14,103 ; P6.16 291.5,103 ; P32.5 15.79,86.36 ; P32.5 13.42,86.36 ; P32.5 14.6,87.54 ; P32.5 14.6,85.18 ; 211.06,8.18 P9.SH2 ; P9.SH2 211.91,9.34 ; P9.SH2 211.91,7.02 ; P9.SH2 212.77,8.18 ; 131.14,190.1 P11.GND1 ; P11.GND1 132.9,191.86 ; P11.GND1 129.37,191.86 ; P11.GND1 131.14,193.63 ; P16.25 288.7,181.09 ; P16.25 287.64,180.03 ; P16.25 286.59,181.09 ; P20.10 48.26,65.57 ; P20.10 48.26,63.21 ; P20.10 47.08,64.39 ; P20.10 49.44,64.39 ; P14.SH3 94.18,180.77 ; P14.SH3 92.05,182.91 ; P14.SH3 89.92,180.77 ; P14.SH3 92.05,178.64 ; 261.75,181.09 P16.16 ; P16.16 263.86,181.09 ; P16.16 262.8,180.03 ; P16.16 262.8,182.14 ; P20.6 48.26,75.73 ; P20.6 48.26,73.37 ; P20.6 47.08,74.55 ; P20.6 49.44,74.55 ; 50.51,61.85 P21.10 ; P21.10 51.69,60.67 ; P21.10 51.69,63.03 ; P21.10 52.87,61.85 ; 71.32,184.68 P14.8A ; P14.8A 71.32,187.17 ; P14.8A 72.57,185.93 ; P19.1_3 340.54,10.9 ; P19.1_3 338.05,10.9 ; P19.1_3 339.29,9.65 ; P9.SH3 211.91,4.61 ; P9.SH3 211.06,3.45 ; P9.SH3 212.77,3.45 ; P14.2B 54.71,180.42 ; P14.2B 55.96,179.17 ; P14.2B 54.71,177.93 ; 329.95,85.18 P33.5 ; P33.5 328.76,86.36 ; P33.5 331.13,86.36 ; P14.11A 79.63,187.17 ; P14.11A 79.63,184.68 ; P14.11A 80.87,185.93 ; 65.93,182.02 P14.19B ; P14.19B 67.17,180.77 ; P14.19B 67.17,183.26 ; 279.36,182.14 P16.22 279.36,180.03 ; 365.85,61.85 P40.10 368.21,61.85 ; P18.2_6 80.53,16.08 ; P18.2_6 80.53,13.59 ; P18.2_6 81.78,14.83 ; P18.2_6 79.29,14.83 ; P20.14 49.44,54.23 ; P20.14 47.08,54.23 ; P20.14 48.26,53.05 ; P20.14 48.26,55.41 ; 187.48,188.06 P13.1 ; P13.1 188.59,189.18 ; P13.1 189.71,188.06 ; P13.1 188.59,186.94 ; P40.4 367.03,47.79 ; P40.4 365.85,46.61 ; P40.4 368.21,46.61 ; P40.4 367.03,45.43 ; 45.06,178.64 P14.SH2 ; P14.SH2 45.06,182.91 ; P14.SH2 47.19,180.77 ; P14.SH2 42.93,180.77 ; 162.14,103 P5.16 ; P5.16 163.32,101.82 ; P5.16 164.5,103 ; P5.16 163.32,104.18 ; P14.16B 58.86,183.26 ; P14.16B 58.86,180.77 ; P14.16B 60.11,182.02 ; P14.16B 57.62,182.02 ; 83.78,187.53 P14.25A ; P14.25A 85.03,188.77 ; P14.25A 82.54,188.77 ; P39.20 363.6,40.17 ; P39.20 364.78,38.99 ; P39.20 362.42,38.99 ; P39.20 363.6,37.81 ; 48.26,68.29 P20.8 ; P20.8 47.08,69.47 ; P20.8 49.44,69.47 ; P20.8 48.26,70.65 ; 363.6,47.97 P39.16 ; P39.16 362.42,49.15 ; P39.16 364.78,49.15 ; 79.63,177.93 P14.11B 79.63,180.42 ; 149.04,180.56 P12.GND4 ; P12.GND4 150.8,182.33 ; P12.GND4 150.8,178.8 ; P12.GND4 152.57,180.56 ; P11.GND4 120.82,180.56 ; P11.GND4 119.05,182.33 ; P11.GND4 119.05,178.8 ; P11.GND4 117.29,180.56 ; 99.78,48.26 P37.12 ; P37.12 102.15,48.26 ; P37.12 100.97,49.44 ; P37.12 100.97,47.08 ; P21.20 52.87,87.25 ; P21.20 50.51,87.25 ; P21.20 51.69,88.43 ; P21.20 51.69,86.07 ; 198.49,79.31 P35.19 ; 151.98,103 P5.8 ; P5.8 153.16,101.82 ; P5.8 154.34,103 ; P5.8 153.16,104.18 ; 50.51,46.61 P21.4 ; P21.4 51.69,45.43 ; P21.4 51.69,47.79 ; P21.4 52.87,46.61 ; P14.25B 83.78,183.26 ; P14.25B 85.03,182.02 ; P14.25B 83.78,180.77 ; P14.25B 82.54,182.02 ; P40.16 368.21,77.09 ; P40.16 365.85,77.09 ; P40.16 367.03,78.27 ; P5.10 156.88,103 ; P5.10 155.7,101.82 ; P5.10 154.52,103 ; P5.10 155.7,104.18 ; 89.92,188.77 P14.SH4 ; P14.SH4 92.05,190.91 ; P14.SH4 92.05,186.64 ; P14.SH4 94.18,188.77 ; 150.62,101.82 P5.6 ; P5.6 149.44,103 ; P5.6 151.8,103 ; P5.6 150.62,104.18 ; P14.22A 76.72,188.77 ; P14.22A 74.23,188.77 ; P14.22A 75.48,187.53 ; 322.33,92.93 P25.1 ; P25.1 323.51,94.11 ; P25.1 321.14,94.11 ; P25.1 322.33,95.29 ; 47.08,49.15 P20.16 ; P20.16 48.26,50.33 ; P20.16 48.26,47.97 ; P20.16 49.44,49.15 ; 180.79,191.86 P13.GND2 ; P13.GND2 184.32,191.86 ; P13.GND2 182.55,190.1 ; P13.GND2 182.55,193.63 ; 368.21,51.69 P40.6 365.85,51.69 ; 275.22,177.19 P16.8 ; P16.8 274.17,178.24 ; P16.8 275.22,179.3 ; 58.86,187.53 P14.16A ; P14.16A 58.86,190.02 ; P14.16A 60.11,188.77 ; P14.5B 64.26,179.17 ; P14.5B 63.02,180.42 ; P14.5B 63.02,177.93 ; P37.11 100.97,46.9 ; P37.11 100.97,44.54 ; P37.11 99.78,45.72 ; P37.11 102.15,45.72 ; 327.41,85.18 P33.7 ; P33.7 328.59,86.36 ; P33.7 326.22,86.36 ; P40.18 367.03,83.35 ; P40.18 365.85,82.17 ; P40.18 368.21,82.17 ; 177.25,101.98 P22.1 ; P22.1 179.62,101.98 ; P22.1 178.43,103.16 ; P22.1 178.43,100.8 ; 362.42,54.23 P39.14 364.78,54.23 ; 286.6,103 P6.14 ; P6.14 288.96,103 ; P6.14 287.78,104.18 ; P37.1 88.27,46.9 ; P37.1 89.45,45.72 ; P37.1 88.27,44.54 ; P37.1 87.08,45.72 ; 321.14,109.86 P27.1 ; P27.1 323.51,109.86 ; P27.1 322.33,108.67 ; P27.1 322.33,111.04 ; P18.2_5 70.84,18.92 ; P18.2_5 72.09,17.68 ; P18.2_5 69.6,17.68 ; P18.2_5 70.84,16.43 ; 180.79,180.56 P13.GND4 ; P13.GND4 182.55,182.33 ; P13.GND4 182.55,178.8 ; P13.GND4 184.32,180.56 ; P11.GND3 132.9,180.56 ; P11.GND3 131.14,182.33 ; P11.GND3 129.37,180.56 ; P11.GND3 131.14,178.8 ; M2.6 385.29,15.9 ; M2.6 384.18,14.78 ; M2.6 383.06,15.9 ; 67.17,187.53 P14.19A 68.42,188.77 ; 364.78,64.39 P39.10 362.42,64.39 ; 362.42,74.55 P39.6 364.78,74.55 ; 362.42,69.47 P39.8 364.78,69.47 ; 266.94,177.19 P16.5 ; P16.5 266.94,179.3 ; P16.5 265.89,178.24 ; 339.29,16.41 P19.2_3 ; P19.2_3 340.54,17.65 ; P19.2_3 338.05,17.65 ; P19.2_3 339.29,18.9 ; 71.32,177.93 P14.8B 71.32,180.42 ; 258.66,179.3 P16.2 258.66,177.19 ; 365.85,66.93 P40.12 368.21,66.93
  L3_SIG w1.016: 324.19,189.69 P7.3 ; P7.3 325.75,188.13 ; P7.3 325.75,191.25 ; P7.3 327.32,189.69 ; 330.45,191.13 P7.2 ; P7.2 332.02,192.69 ; P7.2 328.89,192.69
  L4_GND w0.508: 224.62,191.86 P15.GND1 ; P15.GND1 226.39,193.63 ; P15.GND1 228.15,191.86 ; P15.GND1 226.39,190.1 ; P25.1 323.51,94.11 ; P25.1 322.33,95.29 ; P25.1 321.14,94.11 ; P25.1 322.33,92.93 ; P14.SH2 47.19,180.77 ; P14.SH2 45.06,178.64 ; P14.SH2 42.93,180.77 ; P14.SH2 45.06,182.91 ; 367.03,60.67 P40.10 ; P40.10 365.85,61.85 ; P40.10 368.21,61.85 ; P40.10 367.03,63.03 ; P6.8 280.16,104.18 ; P6.8 278.98,103 ; P6.8 280.16,101.82 ; P6.8 281.34,103 ; P12.GND4 150.8,182.33 ; P12.GND4 149.04,180.56 ; P12.GND4 152.57,180.56 ; P12.GND4 150.8,178.8 ; 365.85,87.25 P40.20 ; P40.20 367.03,86.07 ; P40.20 367.03,88.43 ; P40.20 368.21,87.25 ; P20.12 49.44,59.31 ; P20.12 48.26,58.13 ; P20.12 47.08,59.31 ; P20.12 48.26,60.49 ; 272.54,101.82 P6.2 ; P6.2 271.36,103 ; P6.2 272.54,104.18 ; P6.2 273.72,103 ; 5.8,86.36 P32.11 ; P32.11 8.17,86.36 ; P32.11 6.98,85.18 ; P32.11 6.98,87.54 ; P19.2_5 335,17.65 ; P19.2_5 333.76,16.41 ; P19.2_5 333.76,18.9 ; P19.2_5 332.51,17.65 ; P39.6 364.78,74.55 ; P39.6 363.6,75.73 ; P39.6 363.6,73.37 ; P39.6 362.42,74.55 ; P13.1 188.59,189.18 ; P13.1 187.48,188.06 ; P13.1 188.59,186.94 ; P13.1 189.71,188.06 ; 192.87,180.56 P13.GND3 ; P13.GND3 196.4,180.56 ; P13.GND3 194.64,178.8 ; P13.GND3 194.64,182.33 ; P16.19 271.08,182.14 ; P16.19 270.03,181.09 ; P16.19 271.08,180.03 ; P16.19 272.14,181.09 ; 214.3,178.8 P15.GND4 ; P15.GND4 216.07,180.56 ; P15.GND4 212.54,180.56 ; P15.GND4 214.3,182.33 ; P16.22 280.42,181.09 ; P16.22 278.31,181.09 ; P16.22 279.36,182.14 ; P16.22 279.36,180.03 ; P33.5 329.95,87.54 ; P33.5 331.13,86.36 ; P33.5 328.76,86.36 ; P33.5 329.95,85.18 ; 275.22,177.19 P16.8 ; P16.8 274.17,178.24 ; P16.8 276.28,178.24 ; P16.8 275.22,179.3 ; P12.GND2 152.57,191.86 ; P12.GND2 149.04,191.86 ; P12.GND2 150.8,190.1 ; P12.GND2 150.8,193.63 ; 78.38,185.93 P14.11A ; P14.11A 79.63,184.68 ; P14.11A 80.87,185.93 ; P14.11A 79.63,187.17 ; 79.63,177.93 P14.11B ; P14.11B 80.87,179.17 ; P14.11B 79.63,180.42 ; P14.11B 78.38,179.17 ; 69.6,17.68 P18.2_5 ; P18.2_5 72.09,17.68 ; P18.2_5 70.84,16.43 ; P18.2_5 70.84,18.92 ; 50.51,51.69 P21.6 ; P21.6 51.69,52.87 ; P21.6 51.69,50.51 ; P21.6 52.87,51.69 ; P21.2 52.87,41.53 ; P21.2 51.69,42.71 ; P21.2 50.51,41.53 ; P21.2 51.69,40.35 ; P12.GND3 162.89,182.33 ; P12.GND3 164.65,180.56 ; P12.GND3 162.89,178.8 ; P12.GND3 161.12,180.56 ; P39.12 364.78,59.31 ; P39.12 363.6,58.13 ; P39.12 363.6,60.49 ; P39.12 362.42,59.31 ; 220.34,186.94 P15.1 ; P15.1 220.34,189.18 ; P15.1 219.23,188.06 ; P15.1 221.46,188.06 ; 282.45,178.24 P16.11 ; P16.11 283.5,179.3 ; P16.11 284.56,178.24 ; P16.11 283.5,177.19 ; P14.16A 58.86,190.02 ; P14.16A 60.11,188.77 ; P14.16A 57.62,188.77 ; P14.16A 58.86,187.53 ; 50.51,61.85 P21.10 ; P21.10 52.87,61.85 ; P21.10 51.69,60.67 ; P21.10 51.69,63.03 ; 50.51,72.01 P21.14 ; P21.14 52.87,72.01 ; P21.14 51.69,70.83 ; P21.14 51.69,73.19 ; P20.10 48.26,65.57 ; P20.10 47.08,64.39 ; P20.10 48.26,63.21 ; P20.10 49.44,64.39 ; P6.16 291.5,103 ; P6.16 290.32,104.18 ; P6.16 290.32,101.82 ; P6.16 289.14,103 ; 265.89,178.24 P16.5 ; P16.5 268,178.24 ; P16.5 266.94,179.3 ; P16.5 266.94,177.19 ; P14.19A 68.42,188.77 ; P14.19A 67.17,187.53 ; P14.19A 67.17,190.02 ; P14.19A 65.93,188.77 ; 119.05,190.1 P11.GND2 ; P11.GND2 119.05,193.63 ; P11.GND2 120.82,191.86 ; P11.GND2 117.29,191.86 ; P5.8 153.16,104.18 ; P5.8 153.16,101.82 ; P5.8 151.98,103 ; P5.8 154.34,103 ; P37.11 102.15,45.72 ; P37.11 100.97,46.9 ; P37.11 100.97,44.54 ; P37.11 99.78,45.72 ; P5.6 150.62,104.18 ; P5.6 149.44,103 ; P5.6 151.8,103 ; P5.6 150.62,101.82 ; 211.91,7.02 P9.SH2 ; P9.SH2 211.91,9.34 ; P9.SH2 212.77,8.18 ; P9.SH2 211.06,8.18 ; P21.12 51.69,68.11 ; P21.12 51.69,65.75 ; P21.12 52.87,66.93 ; P21.12 50.51,66.93 ; P18.1_6 80.53,9.32 ; P18.1_6 79.29,8.08 ; P18.1_6 81.78,8.08 ; P18.1_6 80.53,6.83 ; 54.71,184.68 P14.2A ; P14.2A 53.47,185.93 ; P14.2A 54.71,187.17 ; P14.2A 55.96,185.93 ; 157.06,103 P5.12 ; P5.12 159.42,103 ; P5.12 158.24,101.82 ; P5.12 158.24,104.18 ; P40.18 368.21,82.17 ; P40.18 367.03,83.35 ; P40.18 367.03,80.99 ; P40.18 365.85,82.17 ; 367.03,75.91 P40.16 ; P40.16 367.03,78.27 ; P40.16 368.21,77.09 ; P40.16 365.85,77.09 ; P14.SH4 92.05,190.91 ; P14.SH4 94.18,188.77 ; P14.SH4 89.92,188.77 ; P14.SH4 92.05,186.64 ; P5.4 148.08,104.18 ; P5.4 146.9,103 ; P5.4 148.08,101.82 ; P5.4 149.26,103 ; P40.4 367.03,47.79 ; P40.4 367.03,45.43 ; P40.4 368.21,46.61 ; P40.4 365.85,46.61 ; P21.8 52.87,56.77 ; P21.8 51.69,55.59 ; P21.8 51.69,57.95 ; P21.8 50.51,56.77 ; 362.42,79.63 P39.4 ; P39.4 364.78,79.63 ; P39.4 363.6,78.45 ; P39.4 363.6,80.81 ; P33.11 323.51,86.36 ; P33.11 322.33,87.54 ; P33.11 322.33,85.18 ; P33.11 321.14,86.36 ; P40.14 367.03,73.19 ; P40.14 367.03,70.83 ; P40.14 368.21,72.01 ; P40.14 365.85,72.01 ; P39.18 364.78,44.07 ; P39.18 363.6,45.25 ; P39.18 362.42,44.07 ; P39.18 363.6,42.89 ; P12.1 156.84,189.18 ; P12.1 155.73,188.06 ; P12.1 157.96,188.06 ; P12.1 156.84,186.94 ; P39.2 363.6,85.89 ; P39.2 363.6,83.53 ; P39.2 364.78,84.71 ; P39.2 362.42,84.71 ; P39.16 364.78,49.15 ; P39.16 363.6,50.33 ; P39.16 362.42,49.15 ; P39.16 363.6,47.97 ; 401.09,5.26 J2.S ; J2.S 402.46,6.63 ; J2.S 402.46,3.89 ; J2.S 403.84,5.26 ; P37.1 89.45,45.72 ; P37.1 87.08,45.72 ; P37.1 88.27,46.9 ; P37.1 88.27,44.54 ; P19.1_5 335,10.9 ; P19.1_5 333.76,9.65 ; P19.1_5 333.76,12.14 ; P19.1_5 332.51,10.9 ; 53.47,179.17 P14.2B ; P14.2B 55.96,179.17 ; P14.2B 54.71,180.42 ; P14.2B 54.71,177.93 ; P9.GND2 209.64,10.02 ; P18.2_3 77.62,17.68 ; P18.2_3 76.38,16.43 ; P18.2_3 75.13,17.68 ; P18.2_3 76.38,18.92 ; P19.2_3 339.29,18.9 ; P19.2_3 339.29,16.41 ; P19.2_3 338.05,17.65 ; P19.2_3 340.54,17.65 ; P21.4 52.87,46.61 ; P21.4 50.51,46.61 ; P21.4 51.69,47.79 ; P21.4 51.69,45.43 ; 76.38,9.68 P18.1_3 ; P18.1_3 75.13,10.92 ; P18.1_3 77.62,10.92 ; P18.1_3 76.38,12.17 ; 202.52,8.18 P9.SH1 ; P9.SH1 203.38,9.34 ; P9.SH1 204.23,8.18 ; P9.SH1 203.38,7.02 ; P14.16B 58.86,183.26 ; P14.16B 57.62,182.02 ; P14.16B 60.11,182.02 ; P14.16B 58.86,180.77 ; 47.08,79.63 P20.4 ; P20.4 48.26,78.45 ; P20.4 48.26,80.81 ; P20.4 49.44,79.63 ; P20.8 48.26,70.65 ; P20.8 47.08,69.47 ; P20.8 49.44,69.47 ; P20.8 48.26,68.29 ; P19.1_3 339.29,12.14 ; P19.1_3 340.54,10.9 ; P19.1_3 338.05,10.9 ; P19.1_3 339.29,9.65 ; P39.14 364.78,54.23 ; P39.14 363.6,55.41 ; P39.14 362.42,54.23 ; P39.14 363.6,53.05 ; 262.8,180.03 P16.16 ; P16.16 261.75,181.09 ; P16.16 263.86,181.09 ; P16.16 262.8,182.14 ; P14.SH1 45.06,190.91 ; P14.SH1 45.06,186.64 ; P14.SH1 42.93,188.77 ; P14.SH1 47.19,188.77 ; 12.85,10.9 M1.2 ; M1.2 15.09,10.9 ; M1.2 13.97,12.01 ; M1.2 13.97,9.78 ; P40.2 368.21,41.53 ; P40.2 365.85,41.53 ; P40.2 367.03,42.71 ; P40.2 367.03,40.35 ; P5.14 161.96,103 ; P5.14 160.78,104.18 ; P5.14 160.78,101.82 ; P5.14 159.6,103 ; P39.20 364.78,38.99 ; P39.20 362.42,38.99 ; P39.20 363.6,37.81 ; P39.20 363.6,40.17 ; 211.06,3.45 P9.SH3 ; P9.SH3 211.91,4.61 ; P9.SH3 212.77,3.45 ; P5.2 145.54,104.18 ; P5.2 144.36,103 ; P5.2 145.54,101.82 ; P5.2 146.72,103 ; P5.16 163.32,104.18 ; P5.16 163.32,101.82 ; P5.16 164.5,103 ; P5.16 162.14,103 ; P21.18 52.87,82.17 ; P21.18 50.51,82.17 ; P21.18 51.69,83.35 ; P21.18 51.69,80.99 ; 125.09,186.94 P11.1 ; P11.1 123.98,188.06 ; P11.1 126.21,188.06 ; P11.1 125.09,189.18 ; P23.1 322.33,103.16 ; P23.1 321.14,101.98 ; P23.1 322.33,100.8 ; P23.1 323.51,101.98 ; 363.6,68.29 P39.8 ; P39.8 362.42,69.47 ; P39.8 363.6,70.65 ; P39.8 364.78,69.47 ; 286.6,103 P6.14 ; P6.14 287.78,104.18 ; P6.14 287.78,101.82 ; P6.14 288.96,103 ; P14.22A 75.48,190.02 ; P14.22A 76.72,188.77 ; P14.22A 75.48,187.53 ; P14.22A 74.23,188.77 ; 182.55,190.1 P13.GND2 ; P13.GND2 182.55,193.63 ; P13.GND2 180.79,191.86 ; P13.GND2 184.32,191.86 ; P16.25 288.7,181.09 ; P16.25 287.64,182.14 ; P16.25 286.59,181.09 ; P16.25 287.64,180.03 ; P6.12 286.42,103 ; P6.12 285.24,104.18 ; P6.12 285.24,101.82 ; P6.12 284.06,103 ; P14.5A 63.02,187.17 ; P14.5A 64.26,185.93 ; P14.5A 61.77,185.93 ; P14.5A 63.02,184.68 ; 129.37,180.56 P11.GND3 ; P11.GND3 132.9,180.56 ; P11.GND3 131.14,178.8 ; P11.GND3 131.14,182.33 ; 321.14,109.86 P27.1 ; P27.1 322.33,108.67 ; P27.1 323.51,109.86 ; P27.1 322.33,111.04 ; P37.12 100.97,49.44 ; P37.12 100.97,47.08 ; P37.12 99.78,48.26 ; P37.12 102.15,48.26 ; 48.26,47.97 P20.16 ; P20.16 47.08,49.15 ; P20.16 48.26,50.33 ; P20.16 49.44,49.15 ; 33.43,5.26 J1.S ; J1.S 34.8,6.63 ; J1.S 34.8,3.89 ; J1.S 36.17,5.26 ; M1.6 16.51,17.01 ; M1.6 16.51,14.78 ; M1.6 15.39,15.9 ; M1.6 17.63,15.9 ; 48.26,53.05 P20.14 ; P20.14 49.44,54.23 ; P20.14 47.08,54.23 ; P20.14 48.26,55.41 ; 67.17,180.77 P14.19B ; P14.19B 67.17,183.26 ; P14.19B 65.93,182.02 ; P14.19B 68.42,182.02 ; P14.SH3 94.18,180.77 ; P14.SH3 89.92,180.77 ; P14.SH3 92.05,178.64 ; P14.SH3 92.05,182.91 ; 323.68,86.36 P33.9 ; P33.9 324.87,87.54 ; P33.9 324.87,85.18 ; P33.9 326.05,86.36 ; P40.6 368.21,51.69 ; P40.6 367.03,52.87 ; P40.6 365.85,51.69 ; P40.6 367.03,50.51 ; 71.32,177.93 P14.8B ; P14.8B 72.57,179.17 ; P14.8B 71.32,180.42 ; P14.8B 70.08,179.17 ; P35.17 200.69,80.24 ; P40.12 368.21,66.93 ; P40.12 367.03,65.75 ; P40.12 365.85,66.93 ; P40.12 367.03,68.11 ; 12.06,85.18 P32.7 ; P32.7 10.88,86.36 ; P32.7 13.25,86.36 ; P32.7 12.06,87.54 ; P14.22B 75.48,183.26 ; P14.22B 76.72,182.02 ; P14.22B 74.23,182.02 ; P14.22B 75.48,180.77 ; 380.52,10.9 M2.2 ; M2.2 381.63,9.78 ; M2.2 381.63,12.01 ; M2.2 382.75,10.9 ; P6.6 278.8,103 ; P6.6 277.62,101.82 ; P6.6 276.44,103 ; P6.6 277.62,104.18 ; 47.08,84.71 P20.2 ; P20.2 48.26,83.53 ; P20.2 48.26,85.89 ; P20.2 49.44,84.71 ; P32.5 15.79,86.36 ; P32.5 14.6,87.54 ; P32.5 13.42,86.36 ; P32.5 14.6,85.18 ; P18.1_5 70.84,12.17 ; P18.1_5 69.6,10.92 ; P18.1_5 70.84,9.68 ; P18.1_5 72.09,10.92 ; 50.51,87.25 P21.20 ; P21.20 51.69,88.43 ; P21.20 51.69,86.07 ; P21.20 52.87,87.25 ; P18.2_6 80.53,16.08 ; P18.2_6 79.29,14.83 ; P18.2_6 81.78,14.83 ; P18.2_6 80.53,13.59 ; M2.6 384.18,17.01 ; M2.6 383.06,15.9 ; M2.6 385.29,15.9 ; M2.6 384.18,14.78 ; P15.GND2 216.07,191.86 ; P15.GND2 214.3,190.1 ; P15.GND2 212.54,191.86 ; P15.GND2 214.3,193.63 ; P6.10 282.7,104.18 ; P6.10 282.7,101.82 ; P6.10 281.52,103 ; P6.10 283.88,103 ; P14.25A 83.78,190.02 ; P14.25A 85.03,188.77 ; P14.25A 83.78,187.53 ; P14.25A 82.54,188.77 ; 226.39,178.8 P15.GND3 ; P15.GND3 228.15,180.56 ; P15.GND3 226.39,182.33 ; P15.GND3 224.62,180.56 ; 211.13,9.33 P9.B1 210.45,10.02 ; 194.64,190.1 P13.GND1 ; P13.GND1 194.64,193.63 ; P13.GND1 192.87,191.86 ; P13.GND1 196.4,191.86 ; P40.8 368.21,56.77 ; P40.8 367.03,57.95 ; P40.8 365.85,56.77 ; P40.8 367.03,55.59 ; 131.14,190.1 P11.GND1 ; P11.GND1 129.37,191.86 ; P11.GND1 132.9,191.86 ; P11.GND1 131.14,193.63 ; 327.41,85.18 P33.7 ; P33.7 328.59,86.36 ; P33.7 327.41,87.54 ; P33.7 326.22,86.36 ; 343.45,13.56 P19.2_6 ; P19.2_6 342.2,14.81 ; P19.2_6 343.45,16.05 ; P19.2_6 344.69,14.81 ; P12.GND1 162.89,193.63 ; P12.GND1 164.65,191.86 ; P12.GND1 162.89,190.1 ; P12.GND1 161.12,191.86 ; 180.79,180.56 P13.GND4 ; P13.GND4 182.55,182.33 ; P13.GND4 182.55,178.8 ; P13.GND4 184.32,180.56 ; P9.SH4 203.38,4.61 ; P9.SH4 202.52,3.45 ; P9.SH4 204.23,3.45 ; 82.54,182.02 P14.25B ; P14.25B 85.03,182.02 ; P14.25B 83.78,183.26 ; P14.25B 83.78,180.77 ; P39.10 364.78,64.39 ; P39.10 363.6,63.21 ; P39.10 363.6,65.57 ; P39.10 362.42,64.39 ; P35.5 208.31,80.24 ; P37.2 88.27,49.44 ; P37.2 88.27,47.08 ; P37.2 89.45,48.26 ; P37.2 87.08,48.26 ; 47.08,44.07 P20.18 ; P20.18 49.44,44.07 ; P20.18 48.26,45.25 ; P20.18 48.26,42.89 ; 50.51,77.09 P21.16 ; P21.16 51.69,75.91 ; P21.16 52.87,77.09 ; P21.16 51.69,78.27 ; 342.2,8.05 P19.1_6 ; P19.1_6 344.69,8.05 ; P19.1_6 343.45,6.81 ; P19.1_6 343.45,9.3 ; 155.7,101.82 P5.10 ; P5.10 156.88,103 ; P5.10 154.52,103 ; P5.10 155.7,104.18 ; 178.43,100.8 P22.1 ; P22.1 178.43,103.16 ; P22.1 179.62,101.98 ; P22.1 177.25,101.98 ; 47.08,74.55 P20.6 ; P20.6 48.26,73.37 ; P20.6 48.26,75.73 ; P20.6 49.44,74.55 ; 199.42,80.24 P35.19 198.49,79.31 ; P16.2 258.66,179.3 ; P16.2 257.61,178.24 ; P16.2 258.66,177.19 ; P16.2 259.72,178.24 ; P32.9 9.53,87.54 ; P32.9 8.34,86.36 ; P32.9 9.53,85.18 ; P32.9 10.71,86.36 ; P20.20 49.44,38.99 ; P20.20 48.26,40.17 ; P20.20 48.26,37.81 ; P20.20 47.08,38.99 ; P24.1 178.43,95.29 ; P24.1 178.43,92.93 ; P24.1 179.62,94.11 ; P24.1 177.25,94.11 ; P11.GND4 120.82,180.56 ; P11.GND4 119.05,182.33 ; P11.GND4 117.29,180.56 ; P11.GND4 119.05,178.8 ; P9.GND1 205.65,10.02 ; P14.8A 72.57,185.93 ; P14.8A 70.08,185.93 ; P14.8A 71.32,187.17 ; P14.8A 71.32,184.68 ; 63.02,177.93 P14.5B ; P14.5B 63.02,180.42 ; P14.5B 64.26,179.17 ; P14.5B 61.77,179.17 ; 275.08,101.82 P6.4 ; P6.4 275.08,104.18 ; P6.4 273.9,103 ; P6.4 276.26,103 ; 204.16,9.33 P9.B12 204.84,10.02 ; 177.25,109.86 P26.1 ; P26.1 179.62,109.86 ; P26.1 178.43,108.67 ; P26.1 178.43,111.04 ; P35.3 209.58,80.24 ; P35.15 201.96,80.24
  L4_GND w1.016: P7.2 332.02,192.69 ; P7.2 328.89,192.69 ; P7.2 330.45,191.13 ; P7.3 325.75,191.25 ; P7.3 325.75,188.13 ; P7.3 324.19,189.69 ; P7.3 327.32,189.69
  L5_PWR w0.508: 34.8,3.89 J1.S ; J1.S 34.8,6.63 ; J1.S 33.43,5.26 ; J1.S 36.17,5.26 ; P14.2B 54.71,180.42 ; P14.2B 54.71,177.93 ; P14.2B 53.47,179.17 ; P14.2B 55.96,179.17 ; P18.1_6 80.53,9.32 ; P18.1_6 81.78,8.08 ; P18.1_6 80.53,6.83 ; P18.1_6 79.29,8.08 ; P14.25B 83.78,183.26 ; P14.25B 85.03,182.02 ; P14.25B 83.78,180.77 ; P14.25B 82.54,182.02 ; 161.12,191.86 P12.GND1 ; P12.GND1 164.65,191.86 ; P12.GND1 162.89,193.63 ; P12.GND1 162.89,190.1 ; 70.08,179.17 P14.8B ; P14.8B 72.57,179.17 ; P14.8B 71.32,177.93 ; P14.8B 71.32,180.42 ; 45.06,186.64 P14.SH1 ; P14.SH1 42.93,188.77 ; P14.SH1 47.19,188.77 ; P14.SH1 45.06,190.91 ; M2.2 381.63,12.01 ; M2.2 380.52,10.9 ; M2.2 381.63,9.78 ; M2.2 382.75,10.9 ; 57.62,182.02 P14.16B ; P14.16B 58.86,183.26 ; P14.16B 60.11,182.02 ; P14.16B 58.86,180.77 ; 271.08,180.03 P16.19 ; P16.19 271.08,182.14 ; P16.19 272.14,181.09 ; P16.19 270.03,181.09 ; P18.2_5 72.09,17.68 ; P18.2_5 69.6,17.68 ; P18.2_5 70.84,16.43 ; P18.2_5 70.84,18.92 ; P13.GND4 182.55,182.33 ; P13.GND4 184.32,180.56 ; P13.GND4 180.79,180.56 ; P13.GND4 182.55,178.8 ; 261.75,181.09 P16.16 ; P16.16 262.8,182.14 ; P16.16 262.8,180.03 ; P16.16 263.86,181.09 ; P14.SH3 92.05,182.91 ; P14.SH3 94.18,180.77 ; P14.SH3 92.05,178.64 ; P14.SH3 89.92,180.77 ; P14.22B 76.72,182.02 ; P14.22B 75.48,180.77 ; P14.22B 74.23,182.02 ; P14.22B 75.48,183.26 ; 333.76,9.65 P19.1_5 ; P19.1_5 335,10.9 ; P19.1_5 332.51,10.9 ; P19.1_5 333.76,12.14 ; P14.SH2 45.06,182.91 ; P14.SH2 42.93,180.77 ; P14.SH2 45.06,178.64 ; P14.SH2 47.19,180.77 ; 266.94,177.19 P16.5 ; P16.5 266.94,179.3 ; P16.5 268,178.24 ; P16.5 265.89,178.24 ; 117.29,191.86 P11.GND2 ; P11.GND2 119.05,190.1 ; P11.GND2 120.82,191.86 ; P11.GND2 119.05,193.63 ; M1.2 13.97,12.01 ; M1.2 13.97,9.78 ; M1.2 12.85,10.9 ; M1.2 15.09,10.9 ; P15.1 220.34,189.18 ; P15.1 219.23,188.06 ; P15.1 220.34,186.94 ; P15.1 221.46,188.06 ; 287.64,180.03 P16.25 ; P16.25 288.7,181.09 ; P16.25 287.64,182.14 ; P16.25 286.59,181.09 ; 343.45,13.56 P19.2_6 ; P19.2_6 342.2,14.81 ; P19.2_6 343.45,16.05 ; P19.2_6 344.69,14.81 ; 188.59,186.94 P13.1 ; P13.1 189.71,188.06 ; P13.1 187.48,188.06 ; P13.1 188.59,189.18 ; P19.2_5 335,17.65 ; P19.2_5 332.51,17.65 ; P19.2_5 333.76,16.41 ; P19.2_5 333.76,18.9 ; P19.2_3 340.54,17.65 ; P19.2_3 339.29,18.9 ; P19.2_3 338.05,17.65 ; P19.2_3 339.29,16.41 ; 283.5,177.19 P16.11 ; P16.11 284.56,178.24 ; P16.11 282.45,178.24 ; P16.11 283.5,179.3 ; 401.09,5.26 J2.S ; J2.S 403.84,5.26 ; J2.S 402.46,3.89 ; J2.S 402.46,6.63 ; P19.1_3 340.54,10.9 ; P19.1_3 339.29,9.65 ; P19.1_3 339.29,12.14 ; P19.1_3 338.05,10.9 ; 214.3,190.1 P15.GND2 ; P15.GND2 216.07,191.86 ; P15.GND2 212.54,191.86 ; P15.GND2 214.3,193.63 ; M1.6 16.51,17.01 ; M1.6 15.39,15.9 ; M1.6 16.51,14.78 ; M1.6 17.63,15.9 ; 383.06,15.9 M2.6 ; M2.6 384.18,17.01 ; M2.6 384.18,14.78 ; M2.6 385.29,15.9 ; 212.77,3.45 P9.SH3 211.06,3.45 ; 63.02,177.93 P14.5B ; P14.5B 64.26,179.17 ; P14.5B 63.02,180.42 ; P14.5B 61.77,179.17 ; P12.GND4 152.57,180.56 ; P12.GND4 150.8,182.33 ; P12.GND4 149.04,180.56 ; P12.GND4 150.8,178.8 ; P14.22A 76.72,188.77 ; P14.22A 74.23,188.77 ; P14.22A 75.48,190.02 ; P14.22A 75.48,187.53 ; 69.6,10.92 P18.1_5 ; P18.1_5 70.84,12.17 ; P18.1_5 72.09,10.92 ; P18.1_5 70.84,9.68 ; P14.SH4 94.18,188.77 ; P14.SH4 92.05,186.64 ; P14.SH4 92.05,190.91 ; P14.SH4 89.92,188.77 ; 224.62,180.56 P15.GND3 ; P15.GND3 226.39,178.8 ; P15.GND3 226.39,182.33 ; P15.GND3 228.15,180.56 ; P11.GND4 120.82,180.56 ; P11.GND4 119.05,182.33 ; P11.GND4 119.05,178.8 ; P11.GND4 117.29,180.56 ; 65.93,188.77 P14.19A ; P14.19A 67.17,187.53 ; P14.19A 67.17,190.02 ; P14.19A 68.42,188.77 ; P16.8 276.28,178.24 ; P16.8 274.17,178.24 ; P16.8 275.22,177.19 ; P16.8 275.22,179.3 ; 182.55,190.1 P13.GND2 ; P13.GND2 180.79,191.86 ; P13.GND2 182.55,193.63 ; P13.GND2 184.32,191.86 ; P18.1_3 77.62,10.92 ; P18.1_3 76.38,9.68 ; P18.1_3 76.38,12.17 ; P18.1_3 75.13,10.92 ; 54.71,184.68 P14.2A ; P14.2A 55.96,185.93 ; P14.2A 54.71,187.17 ; P14.2A 53.47,185.93 ; 192.87,191.86 P13.GND1 ; P13.GND1 194.64,190.1 ; P13.GND1 194.64,193.63 ; P13.GND1 196.4,191.86 ; 155.73,188.06 P12.1 ; P12.1 156.84,186.94 ; P12.1 157.96,188.06 ; P12.1 156.84,189.18 ; P18.2_6 81.78,14.83 ; P18.2_6 80.53,16.08 ; P18.2_6 79.29,14.83 ; P18.2_6 80.53,13.59 ; 63.02,184.68 P14.5A ; P14.5A 63.02,187.17 ; P14.5A 64.26,185.93 ; P14.5A 61.77,185.93 ; 162.89,178.8 P12.GND3 ; P12.GND3 164.65,180.56 ; P12.GND3 162.89,182.33 ; P12.GND3 161.12,180.56 ; 204.84,10.02 P9.B12 204.16,9.33 ; P14.16A 58.86,190.02 ; P14.16A 57.62,188.77 ; P14.16A 60.11,188.77 ; P14.16A 58.86,187.53 ; P9.SH4 203.38,4.61 ; P9.SH4 202.52,3.45 ; P9.SH4 204.23,3.45 ; 83.78,187.53 P14.25A ; P14.25A 83.78,190.02 ; P14.25A 82.54,188.77 ; P14.25A 85.03,188.77 ; P11.1 126.21,188.06 ; P11.1 125.09,186.94 ; P11.1 123.98,188.06 ; P11.1 125.09,189.18 ; P19.1_6 344.69,8.05 ; P19.1_6 343.45,6.81 ; P19.1_6 343.45,9.3 ; P19.1_6 342.2,8.05 ; P13.GND3 196.4,180.56 ; P13.GND3 192.87,180.56 ; P13.GND3 194.64,182.33 ; P13.GND3 194.64,178.8 ; 65.93,182.02 P14.19B ; P14.19B 67.17,183.26 ; P14.19B 68.42,182.02 ; P14.19B 67.17,180.77 ; P16.22 279.36,182.14 ; P16.22 278.31,181.09 ; P16.22 279.36,180.03 ; P16.22 280.42,181.09 ; 258.66,177.19 P16.2 ; P16.2 259.72,178.24 ; P16.2 257.61,178.24 ; P16.2 258.66,179.3 ; 76.38,16.43 P18.2_3 ; P18.2_3 75.13,17.68 ; P18.2_3 76.38,18.92 ; P18.2_3 77.62,17.68 ; P9.SH1 204.23,8.18 ; P9.SH1 202.52,8.18 ; P9.SH1 203.38,7.02 ; P9.SH1 203.38,9.34 ; P14.8A 72.57,185.93 ; P14.8A 71.32,184.68 ; P14.8A 70.08,185.93 ; P14.8A 71.32,187.17 ; 129.37,180.56 P11.GND3 ; P11.GND3 132.9,180.56 ; P11.GND3 131.14,178.8 ; P11.GND3 131.14,182.33 ; P12.GND2 150.8,193.63 ; P12.GND2 149.04,191.86 ; P12.GND2 152.57,191.86 ; P12.GND2 150.8,190.1 ; P14.11A 79.63,187.17 ; P14.11A 80.87,185.93 ; P14.11A 78.38,185.93 ; P14.11A 79.63,184.68 ; P15.GND1 228.15,191.86 ; P15.GND1 226.39,193.63 ; P15.GND1 226.39,190.1 ; P15.GND1 224.62,191.86 ; 131.14,190.1 P11.GND1 ; P11.GND1 129.37,191.86 ; P11.GND1 132.9,191.86 ; P11.GND1 131.14,193.63 ; P15.GND4 214.3,182.33 ; P15.GND4 214.3,178.8 ; P15.GND4 216.07,180.56 ; P15.GND4 212.54,180.56 ; P14.11B 79.63,180.42 ; P14.11B 80.87,179.17 ; P14.11B 79.63,177.93 ; P14.11B 78.38,179.17
  L5_PWR w1.016: 324.19,189.69 P7.3 ; P7.3 325.75,191.25 ; P7.3 327.32,189.69 ; P7.3 325.75,188.13 ; P7.2 332.02,192.69 ; P7.2 328.89,192.69 ; P7.2 330.45,191.13
  L6_PWR w0.508: P14.25A 85.03,188.77 ; P14.25A 82.54,188.77 ; P14.25A 83.78,187.53 ; P14.25A 83.78,190.02 ; 45.06,186.64 P14.SH1 ; P14.SH1 47.19,188.77 ; P14.SH1 45.06,190.91 ; P14.SH1 42.93,188.77 ; 194.64,178.8 P13.GND3 ; P13.GND3 194.64,182.33 ; P13.GND3 196.4,180.56 ; P13.GND3 192.87,180.56 ; 70.08,185.93 P14.8A ; P14.8A 71.32,187.17 ; P14.8A 72.57,185.93 ; P14.8A 71.32,184.68 ; 54.71,177.93 P14.2B ; P14.2B 53.47,179.17 ; P14.2B 54.71,180.42 ; P14.2B 55.96,179.17 ; 74.23,182.02 P14.22B ; P14.22B 76.72,182.02 ; P14.22B 75.48,183.26 ; P14.22B 75.48,180.77 ; 78.38,185.93 P14.11A ; P14.11A 80.87,185.93 ; P14.11A 79.63,187.17 ; P14.11A 79.63,184.68 ; 119.05,178.8 P11.GND4 ; P11.GND4 119.05,182.33 ; P11.GND4 120.82,180.56 ; P11.GND4 117.29,180.56 ; P16.2 258.66,179.3 ; P16.2 259.72,178.24 ; P16.2 257.61,178.24 ; P16.2 258.66,177.19 ; P14.SH2 45.06,182.91 ; P14.SH2 42.93,180.77 ; P14.SH2 45.06,178.64 ; P14.SH2 47.19,180.77 ; 89.92,188.77 P14.SH4 ; P14.SH4 92.05,190.91 ; P14.SH4 94.18,188.77 ; P14.SH4 92.05,186.64 ; 265.89,178.24 P16.5 ; P16.5 268,178.24 ; P16.5 266.94,177.19 ; P16.5 266.94,179.3 ; J2.S 402.46,6.63 ; J2.S 401.09,5.26 ; J2.S 403.84,5.26 ; J2.S 402.46,3.89 ; 262.8,180.03 P16.16 ; P16.16 261.75,181.09 ; P16.16 262.8,182.14 ; P16.16 263.86,181.09 ; P16.22 279.36,182.14 ; P16.22 280.42,181.09 ; P16.22 278.31,181.09 ; P16.22 279.36,180.03 ; 123.98,188.06 P11.1 ; P11.1 125.09,186.94 ; P11.1 126.21,188.06 ; P11.1 125.09,189.18 ; 150.8,190.1 P12.GND2 ; P12.GND2 149.04,191.86 ; P12.GND2 152.57,191.86 ; P12.GND2 150.8,193.63 ; 155.73,188.06 P12.1 ; P12.1 156.84,189.18 ; P12.1 156.84,186.94 ; P12.1 157.96,188.06 ; P14.16B 58.86,183.26 ; P14.16B 57.62,182.02 ; P14.16B 60.11,182.02 ; P14.16B 58.86,180.77 ; P14.19A 67.17,190.02 ; P14.19A 65.93,188.77 ; P14.19A 67.17,187.53 ; P14.19A 68.42,188.77 ; 224.62,180.56 P15.GND3 ; P15.GND3 226.39,182.33 ; P15.GND3 228.15,180.56 ; P15.GND3 226.39,178.8 ; P14.11B 80.87,179.17 ; P14.11B 78.38,179.17 ; P14.11B 79.63,180.42 ; P14.11B 79.63,177.93 ; P9.SH3 212.77,3.45 ; P9.SH3 211.91,4.61 ; P9.SH3 211.06,3.45 ; 9.53,85.18 P32.9 ; P32.9 8.34,86.36 ; P32.9 9.53,87.54 ; P32.9 10.71,86.36 ; P32.7 13.25,86.36 ; P32.7 10.88,86.36 ; P32.7 12.06,87.54 ; P32.7 12.06,85.18 ; 162.89,178.8 P12.GND3 ; P12.GND3 162.89,182.33 ; P12.GND3 164.65,180.56 ; P12.GND3 161.12,180.56 ; 202.52,3.45 P9.SH4 ; P9.SH4 204.23,3.45 ; P9.SH4 203.38,4.61 ; P16.11 284.56,178.24 ; P16.11 283.5,179.3 ; P16.11 283.5,177.19 ; P16.11 282.45,178.24 ; 180.79,180.56 P13.GND4 ; P13.GND4 182.55,182.33 ; P13.GND4 184.32,180.56 ; P13.GND4 182.55,178.8 ; 129.37,191.86 P11.GND1 ; P11.GND1 131.14,190.1 ; P11.GND1 132.9,191.86 ; P11.GND1 131.14,193.63 ; P12.GND1 162.89,193.63 ; P12.GND1 162.89,190.1 ; P12.GND1 161.12,191.86 ; P12.GND1 164.65,191.86 ; 182.55,190.1 P13.GND2 ; P13.GND2 180.79,191.86 ; P13.GND2 182.55,193.63 ; P13.GND2 184.32,191.86 ; P11.GND2 120.82,191.86 ; P11.GND2 119.05,193.63 ; P11.GND2 117.29,191.86 ; P11.GND2 119.05,190.1 ; 211.91,7.02 P9.SH2 ; P9.SH2 212.77,8.18 ; P9.SH2 211.91,9.34 ; P9.SH2 211.06,8.18 ; P13.1 189.71,188.06 ; P13.1 188.59,189.18 ; P13.1 188.59,186.94 ; P13.1 187.48,188.06 ; 202.52,8.18 P9.SH1 ; P9.SH1 204.23,8.18 ; P9.SH1 203.38,9.34 ; P9.SH1 203.38,7.02 ; P16.19 272.14,181.09 ; P16.19 270.03,181.09 ; P16.19 271.08,182.14 ; P16.19 271.08,180.03 ; P14.22A 76.72,188.77 ; P14.22A 75.48,187.53 ; P14.22A 74.23,188.77 ; P14.22A 75.48,190.02 ; J1.S 36.17,5.26 ; J1.S 34.8,6.63 ; J1.S 34.8,3.89 ; J1.S 33.43,5.26 ; P14.2A 55.96,185.93 ; P14.2A 54.71,187.17 ; P14.2A 54.71,184.68 ; P14.2A 53.47,185.93 ; 192.87,191.86 P13.GND1 ; P13.GND1 194.64,193.63 ; P13.GND1 196.4,191.86 ; P13.GND1 194.64,190.1 ; 131.14,178.8 P11.GND3 ; P11.GND3 132.9,180.56 ; P11.GND3 131.14,182.33 ; P11.GND3 129.37,180.56 ; 150.8,178.8 P12.GND4 ; P12.GND4 152.57,180.56 ; P12.GND4 149.04,180.56 ; P12.GND4 150.8,182.33 ; 67.17,180.77 P14.19B ; P14.19B 65.93,182.02 ; P14.19B 67.17,183.26 ; P14.19B 68.42,182.02 ; P15.GND1 228.15,191.86 ; P15.GND1 226.39,190.1 ; P15.GND1 226.39,193.63 ; P15.GND1 224.62,191.86 ; 275.22,177.19 P16.8 ; P16.8 274.17,178.24 ; P16.8 276.28,178.24 ; P16.8 275.22,179.3 ; P14.5B 63.02,180.42 ; P14.5B 61.77,179.17 ; P14.5B 63.02,177.93 ; P14.5B 64.26,179.17 ; P32.5 15.79,86.36 ; P32.5 13.42,86.36 ; P32.5 14.6,85.18 ; P32.5 14.6,87.54 ; P14.16A 58.86,190.02 ; P14.16A 58.86,187.53 ; P14.16A 57.62,188.77 ; P14.16A 60.11,188.77 ; 214.3,190.1 P15.GND2 ; P15.GND2 216.07,191.86 ; P15.GND2 214.3,193.63 ; P15.GND2 212.54,191.86 ; P15.GND4 216.07,180.56 ; P15.GND4 214.3,182.33 ; P15.GND4 212.54,180.56 ; P15.GND4 214.3,178.8 ; 63.02,184.68 P14.5A ; P14.5A 64.26,185.93 ; P14.5A 63.02,187.17 ; P14.5A 61.77,185.93 ; 82.54,182.02 P14.25B ; P14.25B 83.78,180.77 ; P14.25B 85.03,182.02 ; P14.25B 83.78,183.26 ; 89.92,180.77 P14.SH3 ; P14.SH3 92.05,178.64 ; P14.SH3 92.05,182.91 ; P14.SH3 94.18,180.77 ; 220.34,186.94 P15.1 ; P15.1 219.23,188.06 ; P15.1 221.46,188.06 ; P15.1 220.34,189.18 ; 286.59,181.09 P16.25 ; P16.25 287.64,182.14 ; P16.25 287.64,180.03 ; P16.25 288.7,181.09 ; P32.11 6.98,87.54 ; P32.11 6.98,85.18 ; P32.11 5.8,86.36 ; P32.11 8.17,86.36 ; P14.8B 71.32,180.42 ; P14.8B 70.08,179.17 ; P14.8B 72.57,179.17 ; P14.8B 71.32,177.93 ; 204.16,9.33 P9.B12 ; P9.B1 211.13,9.33
  L6_PWR w1.016: P7.3 327.32,189.69 ; P7.3 324.19,189.69 ; P7.3 325.75,191.25 ; P7.3 325.75,188.13 ; 328.89,192.69 P7.2 ; P7.2 330.45,191.13 ; P7.2 332.02,192.69
  L7_GND w0.508: P5.8 153.16,104.18 ; P5.8 154.34,103 ; P5.8 151.98,103 ; P5.8 153.16,101.82 ; 322.33,108.67 P27.1 ; P27.1 323.51,109.86 ; P27.1 322.33,111.04 ; P27.1 321.14,109.86 ; P6.2 273.72,103 ; P6.2 271.36,103 ; P6.2 272.54,104.18 ; P6.2 272.54,101.82 ; 34.8,3.89 J1.S ; J1.S 36.17,5.26 ; J1.S 33.43,5.26 ; J1.S 34.8,6.63 ; P19.2_5 335,17.65 ; P19.2_5 333.76,16.41 ; P19.2_5 333.76,18.9 ; P19.2_5 332.51,17.65 ; P11.GND4 120.82,180.56 ; P11.GND4 119.05,182.33 ; P11.GND4 117.29,180.56 ; P11.GND4 119.05,178.8 ; 343.45,13.56 P19.2_6 ; P19.2_6 344.69,14.81 ; P19.2_6 342.2,14.81 ; P19.2_6 343.45,16.05 ; P23.1 323.51,101.98 ; P23.1 322.33,100.8 ; P23.1 321.14,101.98 ; P23.1 322.33,103.16 ; P35.17 200.69,80.24 ; 401.09,5.26 J2.S ; J2.S 402.46,3.89 ; J2.S 402.46,6.63 ; J2.S 403.84,5.26 ; P35.3 209.58,80.24 ; 338.05,10.9 P19.1_3 ; P19.1_3 339.29,12.14 ; P19.1_3 339.29,9.65 ; P19.1_3 340.54,10.9 ; 363.6,42.89 P39.18 ; P39.18 364.78,44.07 ; P39.18 363.6,45.25 ; P39.18 362.42,44.07 ; P37.12 100.97,49.44 ; P37.12 100.97,47.08 ; P37.12 102.15,48.26 ; P37.12 99.78,48.26 ; P16.2 258.66,179.3 ; P16.2 257.61,178.24 ; P16.2 258.66,177.19 ; P16.2 259.72,178.24 ; 290.32,101.82 P6.16 ; P6.16 290.32,104.18 ; P6.16 291.5,103 ; P6.16 289.14,103 ; 61.77,179.17 P14.5B ; P14.5B 64.26,179.17 ; P14.5B 63.02,177.93 ; P14.5B 63.02,180.42 ; P40.6 368.21,51.69 ; P40.6 367.03,52.87 ; P40.6 365.85,51.69 ; P40.6 367.03,50.51 ; P20.20 49.44,38.99 ; P20.20 48.26,40.17 ; P20.20 48.26,37.81 ; P20.20 47.08,38.99 ; 329.95,85.18 P33.5 ; P33.5 329.95,87.54 ; P33.5 331.13,86.36 ; P33.5 328.76,86.36 ; P40.20 368.21,87.25 ; P40.20 367.03,88.43 ; P40.20 367.03,86.07 ; P40.20 365.85,87.25 ; P32.5 14.6,87.54 ; P32.5 13.42,86.36 ; P32.5 15.79,86.36 ; P32.5 14.6,85.18 ; P13.GND3 194.64,182.33 ; P13.GND3 192.87,180.56 ; P13.GND3 194.64,178.8 ; P13.GND3 196.4,180.56 ; 48.26,78.45 P20.4 ; P20.4 49.44,79.63 ; P20.4 48.26,80.81 ; P20.4 47.08,79.63 ; 362.42,54.23 P39.14 ; P39.14 364.78,54.23 ; P39.14 363.6,55.41 ; P39.14 363.6,53.05 ; 51.69,65.75 P21.12 ; P21.12 52.87,66.93 ; P21.12 51.69,68.11 ; P21.12 50.51,66.93 ; 362.42,79.63 P39.4 ; P39.4 364.78,79.63 ; P39.4 363.6,78.45 ; P39.4 363.6,80.81 ; P15.1 220.34,189.18 ; P15.1 220.34,186.94 ; P15.1 219.23,188.06 ; P15.1 221.46,188.06 ; 163.32,101.82 P5.16 ; P5.16 164.5,103 ; P5.16 163.32,104.18 ; P5.16 162.14,103 ; 210.45,10.02 P9.B1 211.13,9.33 ; 51.69,86.07 P21.20 ; P21.20 50.51,87.25 ; P21.20 52.87,87.25 ; P21.20 51.69,88.43 ; P32.11 6.98,87.54 ; P32.11 5.8,86.36 ; P32.11 8.17,86.36 ; P32.11 6.98,85.18 ; 42.93,188.77 P14.SH1 ; P14.SH1 45.06,186.64 ; P14.SH1 45.06,190.91 ; P14.SH1 47.19,188.77 ; 224.62,180.56 P15.GND3 ; P15.GND3 226.39,178.8 ; P15.GND3 228.15,180.56 ; P15.GND3 226.39,182.33 ; P21.6 52.87,51.69 ; P21.6 51.69,50.51 ; P21.6 51.69,52.87 ; P21.6 50.51,51.69 ; P5.10 155.7,104.18 ; P5.10 154.52,103 ; P5.10 156.88,103 ; P5.10 155.7,101.82 ; P14.SH3 94.18,180.77 ; P14.SH3 92.05,178.64 ; P14.SH3 92.05,182.91 ; P14.SH3 89.92,180.77 ; P20.18 49.44,44.07 ; P20.18 48.26,42.89 ; P20.18 47.08,44.07 ; P20.18 48.26,45.25 ; P21.2 52.87,41.53 ; P21.2 50.51,41.53 ; P21.2 51.69,42.71 ; P21.2 51.69,40.35 ; P16.22 280.42,181.09 ; P16.22 279.36,180.03 ; P16.22 279.36,182.14 ; P16.22 278.31,181.09 ; 75.48,187.53 P14.22A ; P14.22A 75.48,190.02 ; P14.22A 74.23,188.77 ; P14.22A 76.72,188.77 ; P16.25 288.7,181.09 ; P16.25 287.64,182.14 ; P16.25 287.64,180.03 ; P16.25 286.59,181.09 ; 182.55,178.8 P13.GND4 ; P13.GND4 180.79,180.56 ; P13.GND4 182.55,182.33 ; P13.GND4 184.32,180.56 ; 48.26,47.97 P20.16 ; P20.16 49.44,49.15 ; P20.16 47.08,49.15 ; P20.16 48.26,50.33 ; P6.12 285.24,104.18 ; P6.12 286.42,103 ; P6.12 284.06,103 ; P6.12 285.24,101.82 ; P40.4 368.21,46.61 ; P40.4 365.85,46.61 ; P40.4 367.03,47.79 ; P40.4 367.03,45.43 ; P6.10 282.7,104.18 ; P6.10 282.7,101.82 ; P6.10 281.52,103 ; P6.10 283.88,103 ; 144.36,103 P5.2 ; P5.2 146.72,103 ; P5.2 145.54,104.18 ; P5.2 145.54,101.82 ; P39.16 364.78,49.15 ; P39.16 362.42,49.15 ; P39.16 363.6,50.33 ; P39.16 363.6,47.97 ; P6.4 276.26,103 ; P6.4 273.9,103 ; P6.4 275.08,101.82 ; P6.4 275.08,104.18 ; 160.78,101.82 P5.14 ; P5.14 161.96,103 ; P5.14 160.78,104.18 ; P5.14 159.6,103 ; P39.6 364.78,74.55 ; P39.6 363.6,73.37 ; P39.6 363.6,75.73 ; P39.6 362.42,74.55 ; P16.5 268,178.24 ; P16.5 265.89,178.24 ; P16.5 266.94,177.19 ; P16.5 266.94,179.3 ; P21.4 51.69,47.79 ; P21.4 50.51,46.61 ; P21.4 52.87,46.61 ; P21.4 51.69,45.43 ; 131.14,178.8 P11.GND3 ; P11.GND3 132.9,180.56 ; P11.GND3 131.14,182.33 ; P11.GND3 129.37,180.56 ; 79.29,8.08 P18.1_6 ; P18.1_6 80.53,9.32 ; P18.1_6 80.53,6.83 ; P18.1_6 81.78,8.08 ; 383.06,15.9 M2.6 ; M2.6 384.18,14.78 ; M2.6 384.18,17.01 ; M2.6 385.29,15.9 ; P40.16 368.21,77.09 ; P40.16 367.03,78.27 ; P40.16 367.03,75.91 ; P40.16 365.85,77.09 ; P14.11A 79.63,187.17 ; P14.11A 78.38,185.93 ; P14.11A 79.63,184.68 ; P14.11A 80.87,185.93 ; 48.26,63.21 P20.10 ; P20.10 47.08,64.39 ; P20.10 49.44,64.39 ; P20.10 48.26,65.57 ; P21.10 51.69,63.03 ; P21.10 50.51,61.85 ; P21.10 52.87,61.85 ; P21.10 51.69,60.67 ; 363.6,68.29 P39.8 ; P39.8 362.42,69.47 ; P39.8 363.6,70.65 ; P39.8 364.78,69.47 ; P39.10 364.78,64.39 ; P39.10 363.6,63.21 ; P39.10 363.6,65.57 ; P39.10 362.42,64.39 ; P25.1 322.33,95.29 ; P25.1 322.33,92.93 ; P25.1 321.14,94.11 ; P25.1 323.51,94.11 ; 381.63,9.78 M2.2 ; M2.2 382.75,10.9 ; M2.2 380.52,10.9 ; M2.2 381.63,12.01 ; 277.62,101.82 P6.6 ; P6.6 277.62,104.18 ; P6.6 276.44,103 ; P6.6 278.8,103 ; P14.16A 58.86,190.02 ; P14.16A 57.62,188.77 ; P14.16A 60.11,188.77 ; P14.16A 58.86,187.53 ; P21.14 51.69,73.19 ; P21.14 51.69,70.83 ; P21.14 50.51,72.01 ; P21.14 52.87,72.01 ; 333.76,9.65 P19.1_5 ; P19.1_5 333.76,12.14 ; P19.1_5 335,10.9 ; P19.1_5 332.51,10.9 ; P24.1 178.43,95.29 ; P24.1 178.43,92.93 ; P24.1 179.62,94.11 ; P24.1 177.25,94.11 ; 178.43,108.67 P26.1 ; P26.1 179.62,109.86 ; P26.1 177.25,109.86 ; P26.1 178.43,111.04 ; 50.51,82.17 P21.18 ; P21.18 51.69,80.99 ; P21.18 52.87,82.17 ; P21.18 51.69,83.35 ; P33.11 323.51,86.36 ; P33.11 322.33,85.18 ; P33.11 321.14,86.36 ; P33.11 322.33,87.54 ; 89.92,188.77 P14.SH4 ; P14.SH4 92.05,186.64 ; P14.SH4 92.05,190.91 ; P14.SH4 94.18,188.77 ; 13.97,9.78 M1.2 ; M1.2 13.97,12.01 ; M1.2 12.85,10.9 ; M1.2 15.09,10.9 ; 327.41,85.18 P33.7 ; P33.7 327.41,87.54 ; P33.7 328.59,86.36 ; P33.7 326.22,86.36 ; P19.2_3 339.29,18.9 ; P19.2_3 340.54,17.65 ; P19.2_3 338.05,17.65 ; P19.2_3 339.29,16.41 ; 363.6,37.81 P39.20 ; P39.20 363.6,40.17 ; P39.20 364.78,38.99 ; P39.20 362.42,38.99 ; P14.16B 60.11,182.02 ; P14.16B 57.62,182.02 ; P14.16B 58.86,183.26 ; P14.16B 58.86,180.77 ; 363.6,83.53 P39.2 ; P39.2 363.6,85.89 ; P39.2 364.78,84.71 ; P39.2 362.42,84.71 ; P14.19A 68.42,188.77 ; P14.19A 67.17,187.53 ; P14.19A 67.17,190.02 ; P14.19A 65.93,188.77 ; P5.6 150.62,104.18 ; P5.6 150.62,101.82 ; P5.6 151.8,103 ; P5.6 149.44,103 ; 63.02,184.68 P14.5A ; P14.5A 64.26,185.93 ; P14.5A 63.02,187.17 ; P14.5A 61.77,185.93 ; P12.GND2 152.57,191.86 ; P12.GND2 150.8,193.63 ; P12.GND2 150.8,190.1 ; P12.GND2 149.04,191.86 ; P14.2A 55.96,185.93 ; P14.2A 53.47,185.93 ; P14.2A 54.71,184.68 ; P14.2A 54.71,187.17 ; 47.08,69.47 P20.8 ; P20.8 49.44,69.47 ; P20.8 48.26,68.29 ; P20.8 48.26,70.65 ; P14.25B 83.78,183.26 ; P14.25B 85.03,182.02 ; P14.25B 82.54,182.02 ; P14.25B 83.78,180.77 ; 54.71,177.93 P14.2B ; P14.2B 55.96,179.17 ; P14.2B 53.47,179.17 ; P14.2B 54.71,180.42 ; 161.12,180.56 P12.GND3 ; P12.GND3 162.89,182.33 ; P12.GND3 164.65,180.56 ; P12.GND3 162.89,178.8 ; P18.1_5 70.84,12.17 ; P18.1_5 72.09,10.92 ; P18.1_5 69.6,10.92 ; P18.1_5 70.84,9.68 ; P40.12 367.03,68.11 ; P40.12 368.21,66.93 ; P40.12 367.03,65.75 ; P40.12 365.85,66.93 ; P21.16 51.69,78.27 ; P21.16 50.51,77.09 ; P21.16 51.69,75.91 ; P21.16 52.87,77.09 ; 47.08,84.71 P20.2 ; P20.2 49.44,84.71 ; P20.2 48.26,83.53 ; P20.2 48.26,85.89 ; 75.13,10.92 P18.1_3 ; P18.1_3 76.38,12.17 ; P18.1_3 77.62,10.92 ; P18.1_3 76.38,9.68 ; 99.78,45.72 P37.11 ; P37.11 102.15,45.72 ; P37.11 100.97,46.9 ; P37.11 100.97,44.54 ; P5.4 148.08,104.18 ; P5.4 148.08,101.82 ; P5.4 149.26,103 ; P5.4 146.9,103 ; P32.7 13.25,86.36 ; P32.7 12.06,85.18 ; P32.7 10.88,86.36 ; P32.7 12.06,87.54 ; 177.25,101.98 P22.1 ; P22.1 178.43,103.16 ; P22.1 178.43,100.8 ; P22.1 179.62,101.98 ; 15.39,15.9 M1.6 ; M1.6 16.51,17.01 ; M1.6 16.51,14.78 ; M1.6 17.63,15.9 ; P9.SH1 204.23,8.18 ; P9.SH1 203.38,7.02 ; P9.SH1 202.52,8.18 ; P9.SH1 203.38,9.34 ; P15.GND1 228.15,191.86 ; P15.GND1 226.39,190.1 ; P15.GND1 226.39,193.63 ; P15.GND1 224.62,191.86 ; 202.52,3.45 P9.SH4 ; P9.SH4 204.23,3.45 ; P9.SH4 203.38,4.61 ; P6.8 281.34,103 ; P6.8 280.16,104.18 ; P6.8 278.98,103 ; P6.8 280.16,101.82 ; P18.2_5 70.84,18.92 ; P18.2_5 72.09,17.68 ; P18.2_5 70.84,16.43 ; P18.2_5 69.6,17.68 ; 287.78,101.82 P6.14 ; P6.14 288.96,103 ; P6.14 286.6,103 ; P6.14 287.78,104.18 ; P14.8A 72.57,185.93 ; P14.8A 70.08,185.93 ; P14.8A 71.32,184.68 ; P14.8A 71.32,187.17 ; P19.1_6 344.69,8.05 ; P19.1_6 342.2,8.05 ; P19.1_6 343.45,9.3 ; P19.1_6 343.45,6.81 ; P5.12 158.24,104.18 ; P5.12 159.42,103 ; P5.12 157.06,103 ; P5.12 158.24,101.82 ; 367.03,80.99 P40.18 ; P40.18 368.21,82.17 ; P40.18 367.03,83.35 ; P40.18 365.85,82.17 ; 367.03,40.35 P40.2 ; P40.2 365.85,41.53 ; P40.2 367.03,42.71 ; P40.2 368.21,41.53 ; P14.SH2 47.19,180.77 ; P14.SH2 42.93,180.77 ; P14.SH2 45.06,182.91 ; P14.SH2 45.06,178.64 ; P15.GND4 214.3,182.33 ; P15.GND4 216.07,180.56 ; P15.GND4 214.3,178.8 ; P15.GND4 212.54,180.56 ; 80.53,13.59 P18.2_6 ; P18.2_6 80.53,16.08 ; P18.2_6 81.78,14.83 ; P18.2_6 79.29,14.83 ; P40.10 368.21,61.85 ; P40.10 365.85,61.85 ; P40.10 367.03,60.67 ; P40.10 367.03,63.03 ; P12.1 156.84,189.18 ; P12.1 157.96,188.06 ; P12.1 155.73,188.06 ; P12.1 156.84,186.94 ; P20.14 49.44,54.23 ; P20.14 47.08,54.23 ; P20.14 48.26,55.41 ; P20.14 48.26,53.05 ; 198.49,79.31 P35.19 199.42,80.24 ; P14.8B 72.57,179.17 ; P14.8B 71.32,177.93 ; P14.8B 71.32,180.42 ; P14.8B 70.08,179.17 ; 88.27,47.08 P37.2 ; P37.2 88.27,49.44 ; P37.2 89.45,48.26 ; P37.2 87.08,48.26 ; 149.04,180.56 P12.GND4 ; P12.GND4 150.8,182.33 ; P12.GND4 152.57,180.56 ; P12.GND4 150.8,178.8 ; 192.87,191.86 P13.GND1 ; P13.GND1 196.4,191.86 ; P13.GND1 194.64,190.1 ; P13.GND1 194.64,193.63 ; P9.SH2 211.91,9.34 ; P9.SH2 211.06,8.18 ; P9.SH2 212.77,8.18 ; P9.SH2 211.91,7.02 ; 212.54,191.86 P15.GND2 ; P15.GND2 214.3,190.1 ; P15.GND2 214.3,193.63 ; P15.GND2 216.07,191.86 ; P32.9 9.53,87.54 ; P32.9 10.71,86.36 ; P32.9 8.34,86.36 ; P32.9 9.53,85.18 ; 211.06,3.45 P9.SH3 ; P9.SH3 212.77,3.45 ; P9.SH3 211.91,4.61 ; P33.9 324.87,87.54 ; P33.9 323.68,86.36 ; P33.9 326.05,86.36 ; P33.9 324.87,85.18 ; 82.54,188.77 P14.25A ; P14.25A 85.03,188.77 ; P14.25A 83.78,190.02 ; P14.25A 83.78,187.53 ; P16.16 263.86,181.09 ; P16.16 262.8,182.14 ; P16.16 261.75,181.09 ; P16.16 262.8,180.03 ; 204.84,10.02 P9.B12 204.16,9.33 ; 129.37,191.86 P11.GND1 ; P11.GND1 131.14,193.63 ; P11.GND1 132.9,191.86 ; P11.GND1 131.14,190.1 ; P20.6 49.44,74.55 ; P20.6 48.26,73.37 ; P20.6 48.26,75.73 ; P20.6 47.08,74.55 ; 47.08,59.31 P20.12 ; P20.12 49.44,59.31 ; P20.12 48.26,60.49 ; P20.12 48.26,58.13 ; 119.05,190.1 P11.GND2 ; P11.GND2 117.29,191.86 ; P11.GND2 119.05,193.63 ; P11.GND2 120.82,191.86 ; 270.03,181.09 P16.19 ; P16.19 271.08,182.14 ; P16.19 272.14,181.09 ; P16.19 271.08,180.03 ; P18.2_3 76.38,18.92 ; P18.2_3 76.38,16.43 ; P18.2_3 77.62,17.68 ; P18.2_3 75.13,17.68 ; P21.8 51.69,57.95 ; P21.8 50.51,56.77 ; P21.8 52.87,56.77 ; P21.8 51.69,55.59 ; 75.48,180.77 P14.22B ; P14.22B 74.23,182.02 ; P14.22B 76.72,182.02 ; P14.22B 75.48,183.26 ; P40.8 368.21,56.77 ; P40.8 367.03,55.59 ; P40.8 365.85,56.77 ; P40.8 367.03,57.95 ; P13.GND2 182.55,193.63 ; P13.GND2 184.32,191.86 ; P13.GND2 180.79,191.86 ; P13.GND2 182.55,190.1 ; 274.17,178.24 P16.8 ; P16.8 275.22,177.19 ; P16.8 275.22,179.3 ; P16.8 276.28,178.24 ; P16.11 283.5,179.3 ; P16.11 283.5,177.19 ; P16.11 282.45,178.24 ; P16.11 284.56,178.24 ; 161.12,191.86 P12.GND1 ; P12.GND1 164.65,191.86 ; P12.GND1 162.89,193.63 ; P12.GND1 162.89,190.1 ; P9.GND2 209.64,10.02 ; 367.03,70.83 P40.14 ; P40.14 367.03,73.19 ; P40.14 365.85,72.01 ; P40.14 368.21,72.01 ; 65.93,182.02 P14.19B ; P14.19B 68.42,182.02 ; P14.19B 67.17,183.26 ; P14.19B 67.17,180.77 ; 79.63,177.93 P14.11B ; P14.11B 79.63,180.42 ; P14.11B 78.38,179.17 ; P14.11B 80.87,179.17 ; 363.6,58.13 P39.12 ; P39.12 364.78,59.31 ; P39.12 363.6,60.49 ; P39.12 362.42,59.31 ; P11.1 125.09,189.18 ; P11.1 126.21,188.06 ; P11.1 125.09,186.94 ; P11.1 123.98,188.06 ; P35.5 208.31,80.24 ; 87.08,45.72 P37.1 ; P37.1 88.27,44.54 ; P37.1 89.45,45.72 ; P37.1 88.27,46.9 ; 188.59,186.94 P13.1 ; P13.1 187.48,188.06 ; P13.1 188.59,189.18 ; P13.1 189.71,188.06 ; P35.15 201.96,80.24 ; P9.GND1 205.65,10.02
  L7_GND w1.016: 330.45,191.13 P7.2 ; P7.2 332.02,192.69 ; P7.2 328.89,192.69 ; P7.3 325.75,191.25 ; P7.3 327.32,189.69 ; P7.3 325.75,188.13 ; P7.3 324.19,189.69
  L8_SIG w0.508: 202.52,3.45 P9.SH4 ; P9.SH4 204.23,3.45 ; P9.SH4 203.38,4.61 ; 13.42,86.36 P32.5 ; P32.5 14.6,87.54 ; P32.5 14.6,85.18 ; P32.5 15.79,86.36 ; P6.16 291.5,103 ; P6.16 289.14,103 ; P6.16 290.32,104.18 ; P21.20 52.87,87.25 ; P21.20 50.51,87.25 ; P21.20 51.69,86.07 ; P21.20 51.69,88.43 ; P18.2_3 76.38,18.92 ; P18.2_3 76.38,16.43 ; P18.2_3 77.62,17.68 ; P18.2_3 75.13,17.68 ; P37.12 100.97,49.44 ; P37.12 99.78,48.26 ; P37.12 102.15,48.26 ; P37.12 100.97,47.08 ; P14.11B 80.87,179.17 ; P14.11B 79.63,180.42 ; P14.11B 78.38,179.17 ; P14.11B 79.63,177.93 ; 257.61,178.24 P16.2 ; P16.2 258.66,179.3 ; P16.2 258.66,177.19 ; P16.2 259.72,178.24 ; P37.11 102.15,45.72 ; P37.11 100.97,44.54 ; P37.11 99.78,45.72 ; P37.11 100.97,46.9 ; 51.69,45.43 P21.4 ; P21.4 52.87,46.61 ; P21.4 51.69,47.79 ; P21.4 50.51,46.61 ; 75.13,10.92 P18.1_3 ; P18.1_3 76.38,9.68 ; P18.1_3 77.62,10.92 ; P18.1_3 76.38,12.17 ; 282.45,178.24 P16.11 ; P16.11 283.5,177.19 ; P16.11 283.5,179.3 ; P16.11 284.56,178.24 ; P16.8 275.22,179.3 ; P16.8 276.28,178.24 ; P16.8 275.22,177.19 ; P16.8 274.17,178.24 ; P15.GND1 228.15,191.86 ; P15.GND1 226.39,190.1 ; P15.GND1 224.62,191.86 ; P15.GND1 226.39,193.63 ; 180.79,180.56 P13.GND4 ; P13.GND4 182.55,178.8 ; P13.GND4 184.32,180.56 ; P13.GND4 182.55,182.33 ; 192.87,180.56 P13.GND3 ; P13.GND3 196.4,180.56 ; P13.GND3 194.64,182.33 ; P13.GND3 194.64,178.8 ; 49.44,54.23 P20.14 47.08,54.23 ; 54.71,177.93 P14.2B ; P14.2B 55.96,179.17 ; P14.2B 54.71,180.42 ; P14.2B 53.47,179.17 ; P39.12 364.78,59.31 ; P39.12 363.6,58.13 ; P39.12 363.6,60.49 ; P39.12 362.42,59.31 ; 47.08,38.99 P20.20 ; P20.20 48.26,37.81 ; P20.20 48.26,40.17 ; P20.20 49.44,38.99 ; 285.24,101.82 P6.12 ; P6.12 285.24,104.18 ; P6.12 286.42,103 ; P6.12 284.06,103 ; 57.62,182.02 P14.16B ; P14.16B 58.86,183.26 ; P14.16B 60.11,182.02 ; P14.16B 58.86,180.77 ; 159.6,103 P5.14 ; P5.14 160.78,104.18 ; P5.14 161.96,103 ; 51.69,50.51 P21.6 ; P21.6 50.51,51.69 ; P21.6 52.87,51.69 ; M2.6 384.18,17.01 ; M2.6 383.06,15.9 ; M2.6 384.18,14.78 ; M2.6 385.29,15.9 ; 146.9,103 P5.4 ; P5.4 148.08,104.18 ; P5.4 149.26,103 ; 70.84,9.68 P18.1_5 ; P18.1_5 72.09,10.92 ; P18.1_5 70.84,12.17 ; P18.1_5 69.6,10.92 ; 364.78,49.15 P39.16 363.6,47.97 ; P14.25A 85.03,188.77 ; P14.25A 83.78,190.02 ; P14.25A 83.78,187.53 ; P14.25A 82.54,188.77 ; 187.48,188.06 P13.1 ; P13.1 188.59,186.94 ; P13.1 189.71,188.06 ; 368.21,66.93 P40.12 365.85,66.93 ; 129.37,191.86 P11.GND1 ; P11.GND1 131.14,193.63 ; P11.GND1 131.14,190.1 ; P11.GND1 132.9,191.86 ; 52.87,61.85 P21.10 50.51,61.85 ; M1.2 15.09,10.9 ; M1.2 13.97,9.78 ; M1.2 13.97,12.01 ; M1.2 12.85,10.9 ; 80.53,13.59 P18.2_6 ; P18.2_6 79.29,14.83 ; P18.2_6 81.78,14.83 ; P18.2_6 80.53,16.08 ; P19.1_3 340.54,10.9 ; P19.1_3 339.29,12.14 ; P19.1_3 339.29,9.65 ; P19.1_3 338.05,10.9 ; 368.21,82.17 P40.18 365.85,82.17 ; P14.8A 72.57,185.93 ; P14.8A 71.32,187.17 ; P14.8A 70.08,185.93 ; P14.8A 71.32,184.68 ; 70.84,16.43 P18.2_5 ; P18.2_5 72.09,17.68 ; P18.2_5 69.6,17.68 ; P18.2_5 70.84,18.92 ; 63.02,177.93 P14.5B ; P14.5B 64.26,179.17 ; P14.5B 61.77,179.17 ; P14.5B 63.02,180.42 ; P14.11A 79.63,187.17 ; P14.11A 80.87,185.93 ; P14.11A 79.63,184.68 ; P14.11A 78.38,185.93 ; P6.2 272.54,104.18 ; P6.2 273.72,103 ; P6.2 271.36,103 ; P6.2 272.54,101.82 ; 262.8,180.03 P16.16 ; P16.16 261.75,181.09 ; P16.16 263.86,181.09 ; P16.16 262.8,182.14 ; 80.53,6.83 P18.1_6 ; P18.1_6 80.53,9.32 ; P18.1_6 81.78,8.08 ; P18.1_6 79.29,8.08 ; 50.51,41.53 P21.2 ; P21.2 51.69,42.71 ; P21.2 51.69,40.35 ; P21.2 52.87,41.53 ; 74.23,182.02 P14.22B ; P14.22B 75.48,180.77 ; P14.22B 75.48,183.26 ; P14.22B 76.72,182.02 ; 83.78,180.77 P14.25B ; P14.25B 83.78,183.26 ; P14.25B 85.03,182.02 ; P14.25B 82.54,182.02 ; P40.8 368.21,56.77 ; P40.8 367.03,55.59 ; P40.8 367.03,57.95 ; P39.2 364.78,84.71 ; P39.2 362.42,84.71 ; P39.2 363.6,85.89 ; P24.1 178.43,95.29 ; P24.1 179.62,94.11 ; P24.1 178.43,92.93 ; P24.1 177.25,94.11 ; 365.85,87.25 P40.20 ; P40.20 367.03,86.07 ; P40.20 367.03,88.43 ; P40.20 368.21,87.25 ; 343.45,6.81 P19.1_6 ; P19.1_6 342.2,8.05 ; P19.1_6 343.45,9.3 ; P19.1_6 344.69,8.05 ; 52.87,56.77 P21.8 50.51,56.77 ; 47.08,44.07 P20.18 ; P20.18 49.44,44.07 ; P20.18 48.26,42.89 ; P20.18 48.26,45.25 ; 48.26,47.97 P20.16 ; P20.16 48.26,50.33 ; P20.16 47.08,49.15 ; P20.16 49.44,49.15 ; P11.GND3 131.14,182.33 ; P11.GND3 131.14,178.8 ; P11.GND3 129.37,180.56 ; P11.GND3 132.9,180.56 ; 365.85,77.09 P40.16 368.21,77.09 ; P15.1 221.46,188.06 ; P15.1 219.23,188.06 ; P15.1 220.34,186.94 ; P14.SH3 92.05,182.91 ; P14.SH3 89.92,180.77 ; P14.SH3 94.18,180.77 ; P14.SH3 92.05,178.64 ; 364.78,69.47 P39.8 362.42,69.47 ; P32.9 9.53,87.54 ; P32.9 8.34,86.36 ; P32.9 10.71,86.36 ; P32.9 9.53,85.18 ; 70.08,179.17 P14.8B ; P14.8B 71.32,177.93 ; P14.8B 72.57,179.17 ; P14.8B 71.32,180.42 ; 49.44,59.31 P20.12 47.08,59.31 ; 52.87,72.01 P21.14 50.51,72.01 ; 333.76,9.65 P19.1_5 ; P19.1_5 332.51,10.9 ; P19.1_5 333.76,12.14 ; P19.1_5 335,10.9 ; P6.4 276.26,103 ; P6.4 275.08,104.18 ; P6.4 275.08,101.82 ; P6.4 273.9,103 ; P16.22 280.42,181.09 ; P16.22 279.36,182.14 ; P16.22 278.31,181.09 ; P16.22 279.36,180.03 ; P12.GND4 152.57,180.56 ; P12.GND4 150.8,182.33 ; P12.GND4 149.04,180.56 ; P12.GND4 150.8,178.8 ; P19.2_5 333.76,18.9 ; P19.2_5 333.76,16.41 ; P19.2_5 332.51,17.65 ; P19.2_5 335,17.65 ; P14.SH2 47.19,180.77 ; P14.SH2 42.93,180.77 ; P14.SH2 45.06,178.64 ; P14.SH2 45.06,182.91 ; 47.08,74.55 P20.6 49.44,74.55 ; 381.63,9.78 M2.2 ; M2.2 381.63,12.01 ; M2.2 380.52,10.9 ; M2.2 382.75,10.9 ; 362.42,74.55 P39.6 364.78,74.55 ; 88.27,47.08 P37.2 ; P37.2 89.45,48.26 ; P37.2 88.27,49.44 ; P37.2 87.08,48.26 ; 180.79,191.86 P13.GND2 ; P13.GND2 182.55,190.1 ; P13.GND2 182.55,193.63 ; P13.GND2 184.32,191.86 ; 282.7,101.82 P6.10 ; P6.10 281.52,103 ; P6.10 283.88,103 ; P6.10 282.7,104.18 ; P14.19A 68.42,188.77 ; P14.19A 67.17,190.02 ; P14.19A 67.17,187.53 ; P14.19A 65.93,188.77 ; P14.22A 76.72,188.77 ; P14.22A 75.48,190.02 ; P14.22A 75.48,187.53 ; P14.22A 74.23,188.77 ; 322.33,108.67 P27.1 ; P27.1 322.33,111.04 ; P27.1 321.14,109.86 ; P27.1 323.51,109.86 ; P14.19B 67.17,183.26 ; P14.19B 65.93,182.02 ; P14.19B 67.17,180.77 ; P14.19B 68.42,182.02 ; 162.89,178.8 P12.GND3 ; P12.GND3 161.12,180.56 ; P12.GND3 162.89,182.33 ; P11.GND2 119.05,193.63 ; P11.GND2 120.82,191.86 ; P11.GND2 117.29,191.86 ; P19.2_6 343.45,16.05 ; P19.2_6 342.2,14.81 ; P19.2_6 343.45,13.56 ; P19.2_6 344.69,14.81 ; P15.GND2 216.07,191.86 ; P15.GND2 212.54,191.86 ; P15.GND2 214.3,193.63 ; P6.6 277.62,104.18 ; P6.6 276.44,103 ; P6.6 278.8,103 ; P6.6 277.62,101.82 ; P35.5 208.31,80.24 ; P39.18 364.78,44.07 ; P39.18 363.6,45.25 ; P39.18 362.42,44.07 ; P39.18 363.6,42.89 ; 401.09,5.26 J2.S ; J2.S 402.46,3.89 ; J2.S 402.46,6.63 ; J2.S 403.84,5.26 ; 144.36,103 P5.2 ; P5.2 145.54,104.18 ; P5.2 146.72,103 ; 287.78,101.82 P6.14 ; P6.14 287.78,104.18 ; P6.14 288.96,103 ; P6.14 286.6,103 ; P32.11 8.17,86.36 ; P32.11 6.98,87.54 ; P32.11 6.98,85.18 ; 192.87,191.86 P13.GND1 ; P13.GND1 196.4,191.86 ; P13.GND1 194.64,193.63 ; P37.1 89.45,45.72 ; P37.1 88.27,46.9 ; P37.1 87.08,45.72 ; P37.1 88.27,44.54 ; 365.85,61.85 P40.10 ; P40.10 367.03,60.67 ; P40.10 368.21,61.85 ; P40.10 367.03,63.03 ; P9.SH3 212.77,3.45 ; P9.SH3 211.91,4.61 ; P9.SH3 211.06,3.45 ; P5.10 156.88,103 ; P5.10 154.52,103 ; P5.10 155.7,104.18 ; P6.8 280.16,104.18 ; P6.8 281.34,103 ; P6.8 278.98,103 ; P6.8 280.16,101.82 ; 322.33,95.29 P25.1 323.51,94.11 ; 10.88,86.36 P32.7 ; P32.7 12.06,87.54 ; P32.7 12.06,85.18 ; P32.7 13.25,86.36 ; P40.4 368.21,46.61 ; P40.4 367.03,45.43 ; P40.4 367.03,47.79 ; P40.4 365.85,46.61 ; P35.15 201.96,80.24 ; P5.16 163.32,104.18 ; P5.16 162.14,103 ; P5.16 164.5,103 ; 63.02,184.68 P14.5A ; P14.5A 63.02,187.17 ; P14.5A 64.26,185.93 ; P14.5A 61.77,185.93 ; P9.SH2 212.77,8.18 ; P9.SH2 211.91,9.34 ; P9.SH2 211.06,8.18 ; P9.SH2 211.91,7.02 ; P12.1 157.96,188.06 ; P12.1 156.84,186.94 ; P12.1 155.73,188.06 ; P14.16A 60.11,188.77 ; P14.16A 57.62,188.77 ; P14.16A 58.86,187.53 ; P14.16A 58.86,190.02 ; P23.1 323.51,101.98 ; P23.1 322.33,103.16 ; P23.1 321.14,101.98 ; P23.1 322.33,100.8 ; 151.98,103 P5.8 ; P5.8 153.16,104.18 ; P5.8 154.34,103 ; 365.85,51.69 P40.6 ; P40.6 367.03,50.51 ; P40.6 368.21,51.69 ; P40.6 367.03,52.87 ; P14.2A 54.71,187.17 ; P14.2A 53.47,185.93 ; P14.2A 54.71,184.68 ; P14.2A 55.96,185.93 ; 52.87,77.09 P21.16 50.51,77.09 ; P5.6 150.62,104.18 ; P5.6 149.44,103 ; P5.6 151.8,103 ; P15.GND4 216.07,180.56 ; P15.GND4 214.3,178.8 ; P15.GND4 214.3,182.33 ; 339.29,16.41 P19.2_3 ; P19.2_3 338.05,17.65 ; P19.2_3 340.54,17.65 ; P19.2_3 339.29,18.9 ; 202.52,8.18 P9.SH1 ; P9.SH1 203.38,7.02 ; P9.SH1 203.38,9.34 ; P9.SH1 204.23,8.18 ; M1.6 17.63,15.9 ; M1.6 16.51,17.01 ; M1.6 15.39,15.9 ; M1.6 16.51,14.78 ; P14.SH1 45.06,190.91 ; P14.SH1 47.19,188.77 ; P14.SH1 45.06,186.64 ; P14.SH1 42.93,188.77 ; J1.S 34.8,6.63 ; J1.S 33.43,5.26 ; J1.S 36.17,5.26 ; J1.S 34.8,3.89 ; 157.06,103 P5.12 ; P5.12 158.24,104.18 ; P5.12 159.42,103 ; P12.GND2 152.57,191.86 ; P12.GND2 149.04,191.86 ; P12.GND2 150.8,193.63 ; P12.GND2 150.8,190.1 ; 362.42,79.63 P39.4 364.78,79.63 ; 177.25,101.98 P22.1 179.62,101.98 ; 52.87,82.17 P21.18 50.51,82.17 ; P16.5 268,178.24 ; P16.5 266.94,177.19 ; P16.5 265.89,178.24 ; P16.5 266.94,179.3 ; P16.25 288.7,181.09 ; P16.25 286.59,181.09 ; P16.25 287.64,180.03 ; P16.25 287.64,182.14 ; 119.05,178.8 P11.GND4 ; P11.GND4 117.29,180.56 ; P11.GND4 120.82,180.56 ; P11.GND4 119.05,182.33 ; P12.GND1 164.65,191.86 ; P12.GND1 162.89,193.63 ; P12.GND1 161.12,191.86 ; 177.25,109.86 P26.1 ; P26.1 178.43,111.04 ; P26.1 179.62,109.86 ; 362.42,54.23 P39.14 364.78,54.23 ; 362.42,64.39 P39.10 364.78,64.39 ; 365.85,72.01 P40.14 368.21,72.01 ; 123.98,188.06 P11.1 ; P11.1 125.09,186.94 ; P11.1 126.21,188.06 ; 224.62,180.56 P15.GND3 ; P15.GND3 226.39,182.33 ; P15.GND3 226.39,178.8 ; P15.GND3 228.15,180.56 ; P16.19 271.08,182.14 ; P16.19 272.14,181.09 ; P16.19 271.08,180.03 ; P16.19 270.03,181.09 ; P35.17 200.69,80.24 ; P20.2 48.26,85.89 ; P20.2 49.44,84.71 ; P20.2 47.08,84.71 ; P40.2 368.21,41.53 ; P40.2 367.03,40.35 ; P40.2 367.03,42.71 ; P35.3 209.58,80.24 ; 92.05,186.64 P14.SH4 ; P14.SH4 92.05,190.91 ; P14.SH4 94.18,188.77 ; P14.SH4 89.92,188.77
  L8_SIG w1.016: 328.89,192.69 P7.2 ; P7.2 330.45,191.13 ; P7.2 332.02,192.69 ; 325.75,188.13 P7.3 ; P7.3 324.19,189.69 ; P7.3 325.75,191.25 ; P7.3 327.32,189.69
  L9_GND w0.508: 178.43,108.67 P26.1 ; P26.1 178.43,111.04 ; P26.1 177.25,109.86 ; P26.1 179.62,109.86 ; P24.1 179.62,94.11 ; P24.1 178.43,95.29 ; P24.1 177.25,94.11 ; P24.1 178.43,92.93 ; P11.GND2 120.82,191.86 ; P11.GND2 119.05,190.1 ; P11.GND2 117.29,191.86 ; P11.GND2 119.05,193.63 ; 321.14,101.98 P23.1 ; P23.1 322.33,100.8 ; P23.1 322.33,103.16 ; P23.1 323.51,101.98 ; 5.8,86.36 P32.11 ; P32.11 6.98,87.54 ; P32.11 8.17,86.36 ; P32.11 6.98,85.18 ; P33.9 326.05,86.36 ; P33.9 323.68,86.36 ; P33.9 324.87,87.54 ; P33.9 324.87,85.18 ; P14.16A 58.86,190.02 ; P14.16A 60.11,188.77 ; P14.16A 58.86,187.53 ; P14.16A 57.62,188.77 ; P20.16 48.26,50.33 ; P20.16 49.44,49.15 ; P20.16 47.08,49.15 ; P20.16 48.26,47.97 ; P18.1_3 76.38,12.17 ; P18.1_3 75.13,10.92 ; P18.1_3 77.62,10.92 ; P18.1_3 76.38,9.68 ; 83.78,180.77 P14.25B ; P14.25B 85.03,182.02 ; P14.25B 82.54,182.02 ; P14.25B 83.78,183.26 ; 180.79,180.56 P13.GND4 ; P13.GND4 182.55,178.8 ; P13.GND4 182.55,182.33 ; P13.GND4 184.32,180.56 ; P19.2_5 333.76,18.9 ; P19.2_5 335,17.65 ; P19.2_5 332.51,17.65 ; P19.2_5 333.76,16.41 ; 74.23,182.02 P14.22B ; P14.22B 75.48,183.26 ; P14.22B 76.72,182.02 ; P14.22B 75.48,180.77 ; 342.2,14.81 P19.2_6 ; P19.2_6 343.45,16.05 ; P19.2_6 344.69,14.81 ; P19.2_6 343.45,13.56 ; P9.GND2 209.64,10.02 ; P14.22A 76.72,188.77 ; P14.22A 75.48,187.53 ; P14.22A 75.48,190.02 ; P14.22A 74.23,188.77 ; 290.32,101.82 P6.16 ; P6.16 291.5,103 ; P6.16 289.14,103 ; P6.16 290.32,104.18 ; 149.04,180.56 P12.GND4 ; P12.GND4 150.8,182.33 ; P12.GND4 152.57,180.56 ; P12.GND4 150.8,178.8 ; 365.85,61.85 P40.10 ; P40.10 367.03,60.67 ; P40.10 367.03,63.03 ; P40.10 368.21,61.85 ; 362.42,59.31 P39.12 ; P39.12 364.78,59.31 ; P39.12 363.6,60.49 ; P39.12 363.6,58.13 ; 51.69,50.51 P21.6 ; P21.6 51.69,52.87 ; P21.6 52.87,51.69 ; P21.6 50.51,51.69 ; P6.2 272.54,104.18 ; P6.2 271.36,103 ; P6.2 272.54,101.82 ; P6.2 273.72,103 ; 54.71,184.68 P14.2A ; P14.2A 55.96,185.93 ; P14.2A 54.71,187.17 ; P14.2A 53.47,185.93 ; P11.1 125.09,189.18 ; P11.1 125.09,186.94 ; P11.1 126.21,188.06 ; P11.1 123.98,188.06 ; 178.43,100.8 P22.1 ; P22.1 178.43,103.16 ; P22.1 177.25,101.98 ; P22.1 179.62,101.98 ; 365.85,51.69 P40.6 ; P40.6 368.21,51.69 ; P40.6 367.03,52.87 ; P40.6 367.03,50.51 ; P33.11 322.33,87.54 ; P33.11 322.33,85.18 ; P33.11 323.51,86.36 ; P33.11 321.14,86.36 ; P14.11B 80.87,179.17 ; P14.11B 79.63,180.42 ; P14.11B 79.63,177.93 ; P14.11B 78.38,179.17 ; 258.66,177.19 P16.2 ; P16.2 258.66,179.3 ; P16.2 259.72,178.24 ; P16.2 257.61,178.24 ; 48.26,78.45 P20.4 ; P20.4 48.26,80.81 ; P20.4 49.44,79.63 ; P20.4 47.08,79.63 ; 343.45,6.81 P19.1_6 ; P19.1_6 342.2,8.05 ; P19.1_6 344.69,8.05 ; P19.1_6 343.45,9.3 ; 50.51,87.25 P21.20 ; P21.20 51.69,86.07 ; P21.20 51.69,88.43 ; P21.20 52.87,87.25 ; P40.2 368.21,41.53 ; P40.2 365.85,41.53 ; P40.2 367.03,42.71 ; P40.2 367.03,40.35 ; P5.4 149.26,103 ; P5.4 148.08,104.18 ; P5.4 146.9,103 ; P5.4 148.08,101.82 ; P39.4 363.6,80.81 ; P39.4 364.78,79.63 ; P39.4 362.42,79.63 ; P39.4 363.6,78.45 ; 99.78,48.26 P37.12 ; P37.12 100.97,49.44 ; P37.12 102.15,48.26 ; P37.12 100.97,47.08 ; 365.85,87.25 P40.20 ; P40.20 367.03,86.07 ; P40.20 367.03,88.43 ; P40.20 368.21,87.25 ; 159.6,103 P5.14 ; P5.14 160.78,104.18 ; P5.14 160.78,101.82 ; P5.14 161.96,103 ; P11.GND1 131.14,193.63 ; P11.GND1 131.14,190.1 ; P11.GND1 132.9,191.86 ; P11.GND1 129.37,191.86 ; P18.1_5 70.84,12.17 ; P18.1_5 70.84,9.68 ; P18.1_5 72.09,10.92 ; P18.1_5 69.6,10.92 ; 88.27,47.08 P37.2 ; P37.2 88.27,49.44 ; P37.2 89.45,48.26 ; P37.2 87.08,48.26 ; 92.05,178.64 P14.SH3 ; P14.SH3 89.92,180.77 ; P14.SH3 92.05,182.91 ; P14.SH3 94.18,180.77 ; 119.05,178.8 P11.GND4 ; P11.GND4 119.05,182.33 ; P11.GND4 117.29,180.56 ; P11.GND4 120.82,180.56 ; P14.SH4 92.05,190.91 ; P14.SH4 92.05,186.64 ; P14.SH4 89.92,188.77 ; P14.SH4 94.18,188.77 ; P5.2 145.54,104.18 ; P5.2 144.36,103 ; P5.2 145.54,101.82 ; P5.2 146.72,103 ; 42.93,188.77 P14.SH1 ; P14.SH1 47.19,188.77 ; P14.SH1 45.06,186.64 ; P14.SH1 45.06,190.91 ; 51.69,55.59 P21.8 ; P21.8 52.87,56.77 ; P21.8 51.69,57.95 ; P21.8 50.51,56.77 ; 338.05,10.9 P19.1_3 ; P19.1_3 339.29,12.14 ; P19.1_3 339.29,9.65 ; P19.1_3 340.54,10.9 ; 275.08,101.82 P6.4 ; P6.4 275.08,104.18 ; P6.4 273.9,103 ; P6.4 276.26,103 ; P5.10 155.7,104.18 ; P5.10 156.88,103 ; P5.10 155.7,101.82 ; P5.10 154.52,103 ; P11.GND3 131.14,182.33 ; P11.GND3 129.37,180.56 ; P11.GND3 132.9,180.56 ; P11.GND3 131.14,178.8 ; P15.GND3 226.39,182.33 ; P15.GND3 224.62,180.56 ; P15.GND3 226.39,178.8 ; P15.GND3 228.15,180.56 ; P14.19A 68.42,188.77 ; P14.19A 67.17,190.02 ; P14.19A 67.17,187.53 ; P14.19A 65.93,188.77 ; P25.1 323.51,94.11 ; P25.1 322.33,92.93 ; P25.1 322.33,95.29 ; P25.1 321.14,94.11 ; 53.47,179.17 P14.2B ; P14.2B 54.71,180.42 ; P14.2B 55.96,179.17 ; P14.2B 54.71,177.93 ; 383.06,15.9 M2.6 ; M2.6 385.29,15.9 ; M2.6 384.18,17.01 ; M2.6 384.18,14.78 ; P20.12 48.26,60.49 ; P20.12 47.08,59.31 ; P20.12 48.26,58.13 ; P20.12 49.44,59.31 ; M1.6 16.51,17.01 ; M1.6 16.51,14.78 ; M1.6 17.63,15.9 ; M1.6 15.39,15.9 ; P20.8 48.26,70.65 ; P20.8 49.44,69.47 ; P20.8 47.08,69.47 ; P20.8 48.26,68.29 ; 362.42,44.07 P39.18 ; P39.18 363.6,42.89 ; P39.18 363.6,45.25 ; P39.18 364.78,44.07 ; 33.43,5.26 J1.S ; J1.S 34.8,6.63 ; J1.S 36.17,5.26 ; J1.S 34.8,3.89 ; 367.03,55.59 P40.8 ; P40.8 368.21,56.77 ; P40.8 367.03,57.95 ; P40.8 365.85,56.77 ; P16.16 263.86,181.09 ; P16.16 261.75,181.09 ; P16.16 262.8,182.14 ; P16.16 262.8,180.03 ; P40.14 368.21,72.01 ; P40.14 367.03,73.19 ; P40.14 365.85,72.01 ; P40.14 367.03,70.83 ; P16.8 276.28,178.24 ; P16.8 275.22,179.3 ; P16.8 274.17,178.24 ; P16.8 275.22,177.19 ; P9.SH1 203.38,9.34 ; P9.SH1 203.38,7.02 ; P9.SH1 204.23,8.18 ; P9.SH1 202.52,8.18 ; P20.20 48.26,40.17 ; P20.20 48.26,37.81 ; P20.20 47.08,38.99 ; P20.20 49.44,38.99 ; P18.1_6 80.53,9.32 ; P18.1_6 80.53,6.83 ; P18.1_6 81.78,8.08 ; P18.1_6 79.29,8.08 ; 50.51,66.93 P21.12 ; P21.12 52.87,66.93 ; P21.12 51.69,68.11 ; P21.12 51.69,65.75 ; P18.2_6 81.78,14.83 ; P18.2_6 80.53,13.59 ; P18.2_6 80.53,16.08 ; P18.2_6 79.29,14.83 ; 158.24,101.82 P5.12 ; P5.12 158.24,104.18 ; P5.12 159.42,103 ; P5.12 157.06,103 ; P9.SH3 211.91,4.61 ; P9.SH3 212.77,3.45 ; P9.SH3 211.06,3.45 ; P14.8A 72.57,185.93 ; P14.8A 71.32,184.68 ; P14.8A 70.08,185.93 ; P14.8A 71.32,187.17 ; P14.19B 67.17,183.26 ; P14.19B 67.17,180.77 ; P14.19B 65.93,182.02 ; P14.19B 68.42,182.02 ; 47.08,84.71 P20.2 ; P20.2 48.26,83.53 ; P20.2 48.26,85.89 ; P20.2 49.44,84.71 ; P40.12 367.03,68.11 ; P40.12 367.03,65.75 ; P40.12 365.85,66.93 ; P40.12 368.21,66.93 ; P14.25A 85.03,188.77 ; P14.25A 83.78,190.02 ; P14.25A 82.54,188.77 ; P14.25A 83.78,187.53 ; 48.26,42.89 P20.18 ; P20.18 49.44,44.07 ; P20.18 48.26,45.25 ; P20.18 47.08,44.07 ; P12.1 156.84,189.18 ; P12.1 156.84,186.94 ; P12.1 157.96,188.06 ; P12.1 155.73,188.06 ; 188.59,186.94 P13.1 ; P13.1 187.48,188.06 ; P13.1 189.71,188.06 ; P13.1 188.59,189.18 ; 322.33,108.67 P27.1 ; P27.1 321.14,109.86 ; P27.1 323.51,109.86 ; P27.1 322.33,111.04 ; 47.08,64.39 P20.10 ; P20.10 48.26,65.57 ; P20.10 48.26,63.21 ; P20.10 49.44,64.39 ; P15.GND1 228.15,191.86 ; P15.GND1 226.39,190.1 ; P15.GND1 224.62,191.86 ; P15.GND1 226.39,193.63 ; 76.38,16.43 P18.2_3 ; P18.2_3 75.13,17.68 ; P18.2_3 76.38,18.92 ; P18.2_3 77.62,17.68 ; P19.2_3 340.54,17.65 ; P19.2_3 339.29,16.41 ; P19.2_3 338.05,17.65 ; P19.2_3 339.29,18.9 ; 283.5,177.19 P16.11 ; P16.11 282.45,178.24 ; P16.11 283.5,179.3 ; P16.11 284.56,178.24 ; 329.95,85.18 P33.5 ; P33.5 328.76,86.36 ; P33.5 329.95,87.54 ; P33.5 331.13,86.36 ; 48.26,53.05 P20.14 ; P20.14 48.26,55.41 ; P20.14 47.08,54.23 ; P20.14 49.44,54.23 ; P14.8B 71.32,180.42 ; P14.8B 72.57,179.17 ; P14.8B 70.08,179.17 ; P14.8B 71.32,177.93 ; P9.SH2 211.91,9.34 ; P9.SH2 211.91,7.02 ; P9.SH2 211.06,8.18 ; P9.SH2 212.77,8.18 ; P6.14 287.78,104.18 ; P6.14 287.78,101.82 ; P6.14 288.96,103 ; P6.14 286.6,103 ; 61.77,185.93 P14.5A ; P14.5A 63.02,187.17 ; P14.5A 63.02,184.68 ; P14.5A 64.26,185.93 ; 362.42,84.71 P39.2 ; P39.2 363.6,83.53 ; P39.2 364.78,84.71 ; P39.2 363.6,85.89 ; 362.42,64.39 P39.10 ; P39.10 363.6,63.21 ; P39.10 364.78,64.39 ; P39.10 363.6,65.57 ; P39.16 363.6,50.33 ; P39.16 362.42,49.15 ; P39.16 363.6,47.97 ; P39.16 364.78,49.15 ; 279.36,180.03 P16.22 ; P16.22 279.36,182.14 ; P16.22 278.31,181.09 ; P16.22 280.42,181.09 ; 212.54,180.56 P15.GND4 ; P15.GND4 216.07,180.56 ; P15.GND4 214.3,182.33 ; P15.GND4 214.3,178.8 ; 8.34,86.36 P32.9 ; P32.9 9.53,85.18 ; P32.9 10.71,86.36 ; P32.9 9.53,87.54 ; P5.6 150.62,104.18 ; P5.6 150.62,101.82 ; P5.6 149.44,103 ; P5.6 151.8,103 ; 362.42,38.99 P39.20 ; P39.20 363.6,40.17 ; P39.20 364.78,38.99 ; P39.20 363.6,37.81 ; 402.46,3.89 J2.S ; J2.S 402.46,6.63 ; J2.S 401.09,5.26 ; J2.S 403.84,5.26 ; 87.08,45.72 P37.1 ; P37.1 88.27,44.54 ; P37.1 88.27,46.9 ; P37.1 89.45,45.72 ; 367.03,45.43 P40.4 ; P40.4 368.21,46.61 ; P40.4 367.03,47.79 ; P40.4 365.85,46.61 ; P15.GND2 214.3,193.63 ; P15.GND2 216.07,191.86 ; P15.GND2 212.54,191.86 ; P15.GND2 214.3,190.1 ; P16.5 268,178.24 ; P16.5 266.94,177.19 ; P16.5 266.94,179.3 ; P16.5 265.89,178.24 ; P32.5 15.79,86.36 ; P32.5 13.42,86.36 ; P32.5 14.6,87.54 ; P32.5 14.6,85.18 ; P39.14 364.78,54.23 ; P39.14 362.42,54.23 ; P39.14 363.6,53.05 ; P39.14 363.6,55.41 ; 10.88,86.36 P32.7 ; P32.7 13.25,86.36 ; P32.7 12.06,85.18 ; P32.7 12.06,87.54 ; P6.8 280.16,104.18 ; P6.8 280.16,101.82 ; P6.8 281.34,103 ; P6.8 278.98,103 ; P6.6 277.62,104.18 ; P6.6 278.8,103 ; P6.6 276.44,103 ; P6.6 277.62,101.82 ; 363.6,73.37 P39.6 ; P39.6 364.78,74.55 ; P39.6 363.6,75.73 ; P39.6 362.42,74.55 ; P14.5B 63.02,180.42 ; P14.5B 63.02,177.93 ; P14.5B 64.26,179.17 ; P14.5B 61.77,179.17 ; 282.7,101.82 P6.10 ; P6.10 281.52,103 ; P6.10 283.88,103 ; P6.10 282.7,104.18 ; 362.42,69.47 P39.8 ; P39.8 364.78,69.47 ; P39.8 363.6,70.65 ; P39.8 363.6,68.29 ; M1.2 13.97,12.01 ; M1.2 15.09,10.9 ; M1.2 13.97,9.78 ; M1.2 12.85,10.9 ; P20.6 48.26,75.73 ; P20.6 48.26,73.37 ; P20.6 49.44,74.55 ; P20.6 47.08,74.55 ; P5.8 154.34,103 ; P5.8 153.16,101.82 ; P5.8 151.98,103 ; P5.8 153.16,104.18 ; 161.12,191.86 P12.GND1 ; P12.GND1 162.89,190.1 ; P12.GND1 164.65,191.86 ; P12.GND1 162.89,193.63 ; M2.2 381.63,12.01 ; M2.2 382.75,10.9 ; M2.2 380.52,10.9 ; M2.2 381.63,9.78 ; P9.SH4 203.38,4.61 ; P9.SH4 202.52,3.45 ; P9.SH4 204.23,3.45 ; P40.18 367.03,83.35 ; P40.18 367.03,80.99 ; P40.18 365.85,82.17 ; P40.18 368.21,82.17 ; P21.4 51.69,47.79 ; P21.4 52.87,46.61 ; P21.4 50.51,46.61 ; P21.4 51.69,45.43 ; 51.69,80.99 P21.18 ; P21.18 50.51,82.17 ; P21.18 51.69,83.35 ; P21.18 52.87,82.17 ; P33.7 327.41,87.54 ; P33.7 328.59,86.36 ; P33.7 327.41,85.18 ; P33.7 326.22,86.36 ; P37.11 102.15,45.72 ; P37.11 100.97,46.9 ; P37.11 100.97,44.54 ; P37.11 99.78,45.72 ; P16.19 272.14,181.09 ; P16.19 270.03,181.09 ; P16.19 271.08,180.03 ; P16.19 271.08,182.14 ; 51.69,40.35 P21.2 ; P21.2 50.51,41.53 ; P21.2 52.87,41.53 ; P21.2 51.69,42.71 ; P35.3 209.58,80.24 ; 198.49,79.31 P35.19 199.42,80.24 ; 51.69,70.83 P21.14 ; P21.14 50.51,72.01 ; P21.14 52.87,72.01 ; P21.14 51.69,73.19 ; P15.1 221.46,188.06 ; P15.1 220.34,186.94 ; P15.1 219.23,188.06 ; P15.1 220.34,189.18 ; 69.6,17.68 P18.2_5 ; P18.2_5 70.84,18.92 ; P18.2_5 72.09,17.68 ; P18.2_5 70.84,16.43 ; 332.51,10.9 P19.1_5 ; P19.1_5 333.76,9.65 ; P19.1_5 333.76,12.14 ; P19.1_5 335,10.9 ; P35.15 201.96,80.24 ; 42.93,180.77 P14.SH2 ; P14.SH2 45.06,178.64 ; P14.SH2 47.19,180.77 ; P14.SH2 45.06,182.91 ; P12.GND2 152.57,191.86 ; P12.GND2 149.04,191.86 ; P12.GND2 150.8,190.1 ; P12.GND2 150.8,193.63 ; 57.62,182.02 P14.16B ; P14.16B 58.86,183.26 ; P14.16B 60.11,182.02 ; P14.16B 58.86,180.77 ; P21.10 52.87,61.85 ; P21.10 50.51,61.85 ; P21.10 51.69,63.03 ; P21.10 51.69,60.67 ; P6.12 286.42,103 ; P6.12 284.06,103 ; P6.12 285.24,101.82 ; P6.12 285.24,104.18 ; 163.32,101.82 P5.16 ; P5.16 162.14,103 ; P5.16 164.5,103 ; P5.16 163.32,104.18 ; 51.69,75.91 P21.16 ; P21.16 50.51,77.09 ; P21.16 52.87,77.09 ; P21.16 51.69,78.27 ; 79.63,184.68 P14.11A ; P14.11A 78.38,185.93 ; P14.11A 79.63,187.17 ; P14.11A 80.87,185.93 ; 192.87,180.56 P13.GND3 ; P13.GND3 194.64,182.33 ; P13.GND3 196.4,180.56 ; P13.GND3 194.64,178.8 ; P12.GND3 162.89,182.33 ; P12.GND3 162.89,178.8 ; P12.GND3 164.65,180.56 ; P12.GND3 161.12,180.56 ; P40.16 367.03,78.27 ; P40.16 368.21,77.09 ; P40.16 365.85,77.09 ; P40.16 367.03,75.91 ; 192.87,191.86 P13.GND1 ; P13.GND1 196.4,191.86 ; P13.GND1 194.64,190.1 ; P13.GND1 194.64,193.63 ; P13.GND2 184.32,191.86 ; P13.GND2 182.55,193.63 ; P13.GND2 182.55,190.1 ; P13.GND2 180.79,191.86 ; 286.59,181.09 P16.25 ; P16.25 287.64,180.03 ; P16.25 287.64,182.14 ; P16.25 288.7,181.09 ; P35.17 200.69,80.24 ; 204.16,9.33 P9.B12 204.84,10.02 ; P35.5 208.31,80.24 ; 211.13,9.33 P9.B1 210.45,10.02 ; P9.GND1 205.65,10.02
  L9_GND w1.016: 328.89,192.69 P7.2 ; P7.2 330.45,191.13 ; P7.2 332.02,192.69 ; P7.3 327.32,189.69 ; P7.3 325.75,188.13 ; P7.3 324.19,189.69 ; P7.3 325.75,191.25
  BOTTOM w0.127: J4.21 v1(32.83,78.16) ; J4.6 v1(37.91,72.04) ; J5.2 v1(91.88,72.04) ; J4.58 v1(21.4,72.04) ; J4.90 v1(11.24,72.04) ; J5.29 v1(82.99,78.16) ; J5.58 v1(74.1,72.04) ; J4.65 v1(18.86,78.16) ; J4.45 v1(25.21,78.16) ; J4.42 v1(26.48,72.04) ; J4.86 v1(12.51,72.04) ; J4.92 v1(10.6,71.72) ; J5.46 v1(77.91,72.04) ; J4.70 v1(17.59,72.04) ; J5.74 v1(69.02,72.04) ; J5.42 v1(79.18,72.04) ; J4.69 v1(17.59,78.16) ; J5.38 v1(80.45,72.04) ; J4.73 v1(16.32,78.16) ; J4.46 v1(25.21,72.04) ; J5.77 v1(67.75,78.16) ; J5.10 v1(89.34,72.04) ; J4.49 v1(23.94,78.16) ; J5.92 v1(63.31,71.72) ; J5.25 v1(84.26,78.16) ; J4.10 v1(36.64,72.04) ; J5.65 v1(71.56,78.16) ; J5.78 v1(67.75,72.04) ; J4.54 v1(22.67,72.04) ; J5.50 v1(76.64,72.04) ; J4.57 v1(21.4,78.16) ; J5.34 v1(81.72,72.04) ; J4.9 v1(36.64,78.16) ; J5.81 v1(66.48,78.16) ; J4.62 v1(20.13,72.04) ; J4.18 v1(34.1,72.04) ; J4.82 v1(13.78,72.04) ; J5.73 v1(69.02,78.16) ; J4.66 v1(18.86,72.04) ; J5.30 v1(82.99,72.04) ; J4.22 v1(32.83,72.04) ; J5.9 v1(89.34,78.16) ; J4.38 v1(27.75,72.04) ; J5.45 v1(77.91,78.16) ; J5.86 v1(65.21,72.04) ; J4.94 v1(9.97,72.04) ; J5.93 v1(62.67,78.48) ; J4.5 v1(37.91,78.16) ; J5.37 v1(80.45,78.16) ; J5.49 v1(76.64,78.16) ; J5.94 v1(62.67,72.04) ; J5.62 v1(72.83,72.04) ; J4.25 v1(31.56,78.16) ; J5.90 v1(63.94,72.04) ; J5.91 v1(63.31,78.16) ; J4.81 v1(13.78,78.16) ; J4.93 v1(9.97,78.48) ; J5.41 v1(79.18,78.16) ; J4.61 v1(20.13,78.16) ; J4.2 v1(39.18,72.04) ; J4.91 v1(10.6,78.16) ; J4.50 v1(23.94,72.04) ; J4.78 v1(15.05,72.04) ; J4.74 v1(16.32,72.04) ; J4.26 v1(31.56,72.04) ; J4.77 v1(15.05,78.16) ; J4.33 v1(29.02,78.16) ; J5.70 v1(70.29,72.04) ; J5.6 v1(90.61,72.04) ; J4.29 v1(30.29,78.16) ; J5.14 v1(88.07,72.04) ; J5.17 v1(86.8,78.16) ; J5.57 v1(74.1,78.16) ; J4.1 v1(39.18,78.16) ; J4.13 v1(35.37,78.16) ; J5.66 v1(71.56,72.04) ; J5.69 v1(70.29,78.16) ; J4.17 v1(34.1,78.16) ; J5.54 v1(75.37,72.04) ; J4.41 v1(26.48,78.16) ; J5.89 v1(63.94,78.48) ; J5.1 v1(91.88,78.16) ; J4.14 v1(35.37,72.04) ; J5.22 v1(85.53,72.04) ; J5.61 v1(72.83,78.16) ; J4.53 v1(22.67,78.16) ; J4.30 v1(30.29,72.04) ; J5.26 v1(84.26,72.04) ; J5.13 v1(88.07,78.16) ; J5.5 v1(90.61,78.16) ; J5.53 v1(75.37,78.16) ; J4.89 v1(11.24,78.48) ; J4.37 v1(27.75,78.16) ; J5.18 v1(86.8,72.04) ; J4.34 v1(29.02,72.04) ; J5.33 v1(81.72,78.16) ; J5.21 v1(85.53,78.16) ; J5.82 v1(66.48,72.04)
  BOTTOM w0.178: 104.4,87.89 104.39,87.88 U65.C1 ; U65.B3 v1(102.89,84.59) ; 107.82,83.09 U65.E5
  BOTTOM w0.203: 91.88,75.85 J5.1 92.34,76.9 ; v2(205.84,19.31) 205.84,19.72 C346.2 C332.2 ; U79.6 v1(191.94,80.9) ; C332.2 206.24,21.13 v2(206.24,21.71) 206.24,22.77 205.49,23.52 C354.2 ; C332.2 206.02,20.91 v2(205.45,20.91) ; U37.8 v1(234.01,100.85) ; 354.98,76.9 P3.1 354.52,75.85 ; U36.8 v1(223.98,100.85) ; v1(194.31,35.5) 192.98,35.5 192.77,35.7 U60.3 ; J4.1 39.64,76.9 ; 407.68,76.9 P4.1 407.23,75.85
  BOTTOM w0.254: P21.14 51.69,73.19 ; P21.14 51.69,70.83 ; P21.14 52.87,72.01 ; P21.14 50.51,72.01 ; 381.41,13.06 C379.2 380.87,13.64 ; 335.47,75.85 P3.61 v1(335.47,78.16) ; 20.13,75.85 J4.61 ; 169.04,21.75 PB1.2 171.58,21.75 ; 98.89,105.73 C177.2 ; C177.2 101,105.73 ; C177.2 99.95,106.63 ; C177.2 99.95,104.83 ; 363.6,83.53 P39.2 ; P39.2 362.42,84.71 ; P39.2 363.6,85.89 ; P39.2 364.78,84.71 ; 255.9,79.52 C292.2 255.9,78.35 ; PB2.1 153.44,21.75 ; PB2.1 150.9,21.75 ; PB2.1 152.17,23.02 ; 61.77,179.17 P14.5B ; P14.5B 63.02,177.93 ; P14.5B 63.02,180.42 ; 362.42,69.47 P39.8 ; P39.8 364.78,69.47 ; P39.8 363.6,68.29 ; P39.8 363.6,70.65 ; 48.26,63.21 P20.10 ; P20.10 48.26,65.57 ; P20.10 47.08,64.39 ; P20.10 49.44,64.39 ; 235.25,58.55 C422.2 ; C422.2 236.16,57.49 ; C422.2 236.16,59.6 ; PB4.1 279.17,23.02 ; PB4.1 280.44,21.75 ; PB4.1 277.9,21.75 ; P11.GND3 132.9,180.56 ; P11.GND3 131.14,182.33 ; P11.GND3 129.37,180.56 ; P11.GND3 131.14,178.8 ; 273.9,103 P6.4 ; P6.4 275.08,101.82 ; P6.4 276.26,103 ; P6.4 275.08,104.18 ; 155.7,101.82 P5.10 ; P5.10 155.7,104.18 ; P5.10 154.52,103 ; P5.10 156.88,103 ; P40.12 368.21,66.93 ; P40.12 367.03,65.75 ; P40.12 367.03,68.11 ; P40.12 365.85,66.93 ; 362.42,54.23 P39.14 ; P39.14 364.78,54.23 ; P39.14 363.6,53.05 ; P39.14 363.6,55.41 ; 57.62,182.02 P14.16B ; P14.16B 58.86,183.26 ; P14.16B 58.86,180.77 ; P14.16B 60.11,182.02 ; 341.82,74.35 P3.42 v1(341.82,72.04) ; 340.55,75.85 P3.45 v1(340.55,78.16) ; 117.04,96.29 R353.2 117.04,95.04 ; P14.25A 83.78,190.02 ; P14.25A 85.03,188.77 ; P14.25A 82.54,188.77 ; 21.4,75.85 J4.57 ; 367.03,45.43 P40.4 ; P40.4 368.21,46.61 ; P40.4 367.03,47.79 ; P40.4 365.85,46.61 ; P5.6 151.8,103 ; P5.6 150.62,104.18 ; P5.6 150.62,101.82 ; v1(395.8,78.16) P4.37 395.8,75.85 ; 259.72,49.23 C59.2 259.18,48.64 ; J5.74 69.02,74.35 ; P13.GND4 182.55,182.33 ; P13.GND4 182.55,178.8 ; P13.GND4 184.32,180.56 ; P13.GND4 180.79,180.56 ; P40.18 367.03,83.35 ; P40.18 365.85,82.17 ; P40.18 367.03,80.99 ; P40.18 368.21,82.17 ; 225.86,44.46 R22.2 225.29,45.08 ; 12.95,32.12 U67.14 11.6,32.12 ; P9.GND2 209.64,10.02 ; P40.14 367.03,73.19 ; P40.14 367.03,70.83 ; P40.14 365.85,72.01 ; P40.14 368.21,72.01 ; U69.6 384.26,30.62 ; 119.05,178.8 P11.GND4 ; P11.GND4 119.05,182.33 ; P11.GND4 117.29,180.56 ; P11.GND4 120.82,180.56 ; 90.61,75.85 J5.5 ; 294.82,103.25 R349.2 294.82,104.5 ; C68.2 253.57,40.74 ; P16.16 263.86,181.09 ; P16.16 262.8,180.03 ; P16.16 262.8,182.14 ; P16.16 261.75,181.09 ; 367.03,50.51 P40.6 ; P40.6 367.03,52.87 ; P40.6 368.21,51.69 ; P40.6 365.85,51.69 ; P9.B1 210.45,10.02 ; 343.09,75.85 P3.37 v1(343.09,78.16) ; v1(378.65,71.72) P4.92 378.65,74.35 ; P16.5 268,178.24 ; P16.5 266.94,177.19 ; P16.5 266.94,179.3 ; P16.5 265.89,178.24 ; 345.63,75.85 P3.29 v1(345.63,78.16) ; J5.34 81.72,74.35 ; 224.62,180.56 P15.GND3 ; P15.GND3 228.15,180.56 ; P15.GND3 226.39,178.8 ; P15.GND3 226.39,182.33 ; 330.39,74.35 P3.78 v1(330.39,72.04) ; 156.84,186.94 P12.1 ; P12.1 157.96,188.06 ; P12.1 155.73,188.06 ; P12.1 156.84,189.18 ; J4.92 10.6,74.35 ; 226.56,103.87 R352.2 227.13,104.5 ; 325.95,75.85 P3.91 v1(325.95,78.16) ; 275.64,81.35 C24.2 276.81,81.35 ; 378.34,33.58 C382.2 378.34,34.75 ; 187.48,188.06 P13.1 ; P13.1 188.59,189.18 ; P13.1 188.59,186.94 ; P13.1 189.71,188.06 ; 398.34,75.85 P4.29 v1(398.34,78.16) ; 400.88,75.85 P4.21 v1(400.88,78.16) ; 270.03,181.09 P16.19 ; P16.19 271.08,180.03 ; P16.19 271.08,182.14 ; P16.19 272.14,181.09 ; 85.53,75.85 J5.21 ; 179.62,94.11 P24.1 177.25,94.11 ; v1(325.95,71.72) P3.92 325.95,74.35 ; 214.3,190.1 P15.GND2 ; P15.GND2 212.54,191.86 ; P15.GND2 214.3,193.63 ; P15.GND2 216.07,191.86 ; P39.6 363.6,75.73 ; P39.6 362.42,74.55 ; P39.6 363.6,73.37 ; P39.6 364.78,74.55 ; v1(391.99,72.04) P4.50 391.99,74.35 ; 117.29,191.86 P11.GND2 ; P11.GND2 120.82,191.86 ; P11.GND2 119.05,193.63 ; v1(332.93,72.04) P3.70 332.93,74.35 ; J5.42 79.18,74.35 ; C189.2 104.81,114.62 ; C189.2 102.7,114.62 ; C189.2 103.76,115.52 ; C189.2 103.76,113.72 ; 88.27,44.54 P37.1 ; P37.1 87.08,45.72 ; P37.1 89.45,45.72 ; P37.1 88.27,46.9 ; U46.8 v1(140.84,83.47) ; U46.8 140.04,83.87 ; U46.8 139.36,83.47 ; v1(378.02,72.04) P4.94 378.02,74.35 ; 305.62,104.81 C74.2 305.62,105.98 ; P18.1_5 72.09,10.92 ; P18.1_5 69.6,10.92 ; P18.1_5 70.84,12.17 ; P18.1_5 70.84,9.68 ; P20.18 48.26,45.25 ; P20.18 47.08,44.07 ; P20.18 49.44,44.07 ; P20.18 48.26,42.89 ; P14.19A 68.42,188.77 ; P14.19A 67.17,190.02 ; P14.19A 65.93,188.77 ; P14.19A 67.17,187.53 ; P6.12 285.24,104.18 ; P6.12 285.24,101.82 ; P6.12 284.06,103 ; P6.12 286.42,103 ; 209.68,15.91 C348.2 ; P20.12 48.26,60.49 ; P20.12 47.08,59.31 ; P20.12 49.44,59.31 ; P20.12 48.26,58.13 ; v1(397.07,72.04) P4.34 397.07,74.35 ; P14.19B 67.17,183.26 ; P14.19B 67.17,180.77 ; P14.19B 65.93,182.02 ; v1(334.2,72.04) P3.66 334.2,74.35 ; 25.21,75.85 J4.45 ; C373.2 15.74,19.48 ; 323.51,101.98 P23.1 322.33,100.8 ; P16.22 279.36,182.14 ; P16.22 279.36,180.03 ; P16.22 280.42,181.09 ; P16.22 278.31,181.09 ; 280.16,101.82 P6.8 ; P6.8 281.34,103 ; P6.8 280.16,104.18 ; P6.8 278.98,103 ; 150.8,190.1 P12.GND2 ; P12.GND2 149.04,191.86 ; P12.GND2 150.8,193.63 ; P12.GND2 152.57,191.86 ; P18.2_5 70.84,18.92 ; P18.2_5 69.6,17.68 ; P18.2_5 72.09,17.68 ; P18.2_5 70.84,16.43 ; 10.68,33.58 C295.2 10.68,34.75 ; 92.05,186.64 P14.SH4 ; P14.SH4 92.05,190.91 ; P14.SH4 94.18,188.77 ; P14.SH4 89.92,188.77 ; 194.64,190.1 P13.GND1 ; P13.GND1 194.64,193.63 ; P13.GND1 192.87,191.86 ; P13.GND1 196.4,191.86 ; P16.11 284.56,178.24 ; P16.11 282.45,178.24 ; P16.11 283.5,177.19 ; P16.11 283.5,179.3 ; 282.7,101.82 P6.10 ; P6.10 282.7,104.18 ; P6.10 283.88,103 ; P6.10 281.52,103 ; 402.15,75.85 P4.17 v1(402.15,78.16) ; P19.2_5 335,17.65 ; P19.2_5 332.51,17.65 ; P19.2_5 333.76,16.41 ; P19.2_5 333.76,18.9 ; 350.71,75.85 P3.13 v1(350.71,78.16) ; P16.8 276.28,178.24 ; P16.8 274.17,178.24 ; P16.8 275.22,179.3 ; P16.8 275.22,177.19 ; 82.54,7.48 D5.3 82.54,8.77 ; 257.61,178.24 P16.2 ; P16.2 259.72,178.24 ; P16.2 258.66,179.3 ; P16.2 258.66,177.19 ; 45.06,178.64 P14.SH2 ; P14.SH2 42.93,180.77 ; P14.SH2 47.19,180.77 ; P14.SH2 45.06,182.91 ; v1(390.72,78.16) P4.53 390.72,75.85 ; P3.1 v1(354.52,78.16) ; 203.38,7.02 P9.SH1 ; P9.SH1 203.38,9.34 ; P9.SH1 202.52,8.18 ; P9.SH1 204.23,8.18 ; 117.78,97.52 R355.2 117.78,98.76 ; 204.95,23.65 C354.2 205.49,24.24 ; U35.8 v1(311.74,100.85) ; U35.8 310.19,100.85 ; U35.8 310.86,100.46 ; 97.79,118.16 C187.2 ; C187.2 97.79,119.96 ; C187.2 96.74,119.06 ; C187.2 98.84,119.06 ; P32.9 9.53,87.54 ; P32.9 9.53,85.18 ; P32.9 10.71,86.36 ; P32.9 8.34,86.36 ; 345.45,15.48 D8.3 345.45,14.18 ; 18.86,75.85 J4.65 ; 161.12,191.86 P12.GND1 ; P12.GND1 164.65,191.86 ; P12.GND1 162.89,190.1 ; P12.GND1 162.89,193.63 ; 349.44,75.85 P3.17 v1(349.44,78.16) ; 122.14,104.88 C171.2 121.59,104.3 ; 17.59,75.85 J4.69 ; P33.5 331.13,86.36 ; P33.5 329.95,85.18 ; P33.5 329.95,87.54 ; P33.5 328.76,86.36 ; 151.98,103 P5.8 ; P5.8 154.34,103 ; P5.8 153.16,104.18 ; P5.8 153.16,101.82 ; P9.SH3 212.77,3.45 ; P9.SH3 211.06,3.45 ; P9.SH3 211.91,4.61 ; v1(338.01,72.04) P3.54 338.01,74.35 ; U47.8 250.53,83.87 ; U47.8 249.85,83.47 ; U47.8 v1(251.33,83.47) ; J5.92 63.31,74.35 ; P15.GND1 226.39,193.63 ; P15.GND1 224.62,191.86 ; P15.GND1 228.15,191.86 ; P15.GND1 226.39,190.1 ; P6.16 291.5,103 ; P6.16 290.32,104.18 ; P6.16 290.32,101.82 ; P6.16 289.14,103 ; 231.91,56.15 R595.2 231.91,57.39 ; 98.94,90.69 R34.2 98.94,91.94 ; 193.27,37.19 U60.2 v1(194.31,36.49) ; 10.6,75.85 J4.91 ; 78.38,179.17 P14.11B ; P14.11B 79.63,180.42 ; P14.11B 79.63,177.93 ; 258.23,91.6 U62.8 v1(260.21,91.6) ; P35.17 200.69,80.24 ; 200.38,20.89 C337.2 ; 82.54,14.21 D6.3 82.54,15.5 ; 118.67,99.1 C269.2 118.67,100.27 ; v1(332.93,78.16) P3.69 332.93,75.85 ; P37.12 102.15,48.26 ; P37.12 100.97,49.44 ; P37.12 100.97,47.08 ; 61.77,185.93 P14.5A ; P14.5A 64.26,185.93 ; P14.5A 63.02,187.17 ; P14.5A 63.02,184.68 ; J4.90 11.24,74.35 ; 13.78,75.85 J4.81 ; 87.96,21.85 C278.2 86.79,21.85 ; C429.2 v1(186.51,80.14) ; C429.2 187.33,80.72 ; C429.2 187.33,79.55 ; J4.30 30.29,74.35 ; 112.48,128.84 C186.2 ; C186.2 113.54,129.74 ; C186.2 113.54,127.94 ; C186.2 114.59,128.84 ; 326.58,75.85 P3.89 v1(326.58,78.48) ; 261.88,90.1 U62.12 v1(263.35,90.1) ; 220.34,186.94 P15.1 ; P15.1 219.23,188.06 ; P15.1 221.46,188.06 ; P15.1 220.34,189.18 ; P20.2 49.44,84.71 ; P20.2 48.26,83.53 ; P20.2 47.08,84.71 ; P20.2 48.26,85.89 ; 88.07,75.85 J5.13 ; J5.94 62.67,74.35 ; 53.47,185.93 P14.2A ; P14.2A 54.71,187.17 ; P14.2A 54.71,184.68 ; P14.2A 55.96,185.93 ; P35.15 201.96,80.24 ; C334.2 212.32,20.76 ; 291.62,21.75 PB3.1 294.16,21.75 ; 54.71,177.93 P14.2B ; P14.2B 53.47,179.17 ; P14.2B 54.71,180.42 ; 225.3,54.52 C424.2 224.42,55.27 ; 340.55,74.35 P3.46 v1(340.55,72.04) ; 388.18,75.85 P4.61 v1(388.18,78.16) ; J5.6 90.61,74.35 ; 380.61,31.12 U69.12 379.27,31.12 ; PB4.2 284.86,21.75 ; PB4.2 282.32,21.75 ; PB4.2 283.59,23.02 ; 131.14,190.1 P11.GND1 ; P11.GND1 132.9,191.86 ; P11.GND1 129.37,191.86 ; P11.GND1 131.14,193.63 ; P4.1 v1(407.23,78.16) ; 82.54,182.02 P14.25B ; P14.25B 85.03,182.02 ; P14.25B 83.78,183.26 ; P14.25B 83.78,180.77 ; 345.45,8.75 D7.3 345.45,7.45 ; P13.GND3 194.64,182.33 ; P13.GND3 196.4,180.56 ; P13.GND3 192.87,180.56 ; P13.GND3 194.64,178.8 ; 244.22,20.48 S14.2 ; S14.2 245.49,21.75 ; S14.2 242.95,21.75 ; 189.53,38.03 U60.9 190.23,38.4 ; 51.69,40.35 P21.2 ; P21.2 51.69,42.71 ; P21.2 52.87,41.53 ; P39.20 363.6,40.17 ; P39.20 362.42,38.99 ; P39.20 364.78,38.99 ; P39.20 363.6,37.81 ; 272.41,79.52 C293.2 272.41,78.35 ; J4.22 32.83,74.35 ; P12.GND3 164.65,180.56 ; P12.GND3 162.89,182.33 ; P12.GND3 162.89,178.8 ; P12.GND3 161.12,180.56 ; 22.67,75.85 J4.53 ; 134.88,90.1 U61.12 v1(136.35,90.1) ; C184.2 113.41,115.52 ; C184.2 113.41,113.72 ; C184.2 112.36,114.62 ; C184.2 114.47,114.62 ; P40.8 367.03,57.95 ; P40.8 365.85,56.77 ; P40.8 367.03,55.59 ; P40.8 368.21,56.77 ; P9.SH2 212.77,8.18 ; P9.SH2 211.91,9.34 ; P9.SH2 211.91,7.02 ; v1(263.35,91.1) U62.10 261.88,91.1 ; 362.42,44.07 P39.18 ; P39.18 363.6,42.89 ; P39.18 363.6,45.25 ; P39.18 364.78,44.07 ; C69.2 218.06,84.66 ; C69.2 217,83.76 ; C69.2 219.11,83.76 ; 228.34,57.39 R597.2 228.34,56.15 ; 326.58,74.35 P3.90 v1(326.58,72.04) ; P4.2 v1(407.23,72.04) ; P4.2 407.68,73.3 ; P4.2 407.23,74.35 ; 381.83,75.85 P4.81 v1(381.83,78.16) ; P33.9 326.05,86.36 ; P33.9 324.87,87.54 ; P33.9 323.68,86.36 ; P33.9 324.87,85.18 ; 377.58,33.26 R534.2 377.58,32.02 ; 146.04,79.83 R409.2 146.04,81.08 ; P11.1 125.09,189.18 ; P11.1 126.21,188.06 ; P11.1 125.09,186.94 ; P11.1 123.98,188.06 ; C180.2 103.54,105.73 ; C180.2 101.43,105.73 ; C180.2 102.49,106.63 ; C180.2 102.49,104.83 ; J4.86 12.51,74.35 ; P39.12 363.6,60.49 ; P39.12 362.42,59.31 ; P39.12 364.78,59.31 ; P39.12 363.6,58.13 ; U69.7 384.26,30.12 ; P33.7 328.59,86.36 ; P33.7 326.22,86.36 ; P33.7 327.41,87.54 ; P33.7 327.41,85.18 ; v1(349.44,72.04) P3.18 349.44,74.35 ; 249.25,26.54 C383.2 248.67,27.08 ; v1(334.2,78.16) P3.65 334.2,75.85 ; 134.88,89.6 U61.13 v1(136.86,89.6) ; 240.42,26.11 C394.2 240.42,24.94 ; 182.55,190.1 P13.GND2 ; P13.GND2 182.55,193.63 ; P13.GND2 180.79,191.86 ; P13.GND2 184.32,191.86 ; 57.62,188.77 P14.16A ; P14.16A 58.86,190.02 ; P14.16A 60.11,188.77 ; P14.16A 58.86,187.53 ; 339.28,74.35 P3.50 v1(339.28,72.04) ; 351.98,74.35 P3.10 v1(351.98,72.04) ; P21.4 52.87,46.61 ; P21.4 51.69,47.79 ; P21.4 50.51,46.61 ; P21.4 51.69,45.43 ; U69.5 384.26,31.12 ; J4.54 22.67,74.35 ; J5.66 71.56,74.35 ; J4.26 31.56,74.35 ; P40.10 368.21,61.85 ; P40.10 367.03,60.67 ; P40.10 367.03,63.03 ; P40.10 365.85,61.85 ; 399.61,75.85 P4.25 v1(399.61,78.16) ; v1(405.96,72.04) P4.6 405.96,74.35 ; v1(136.35,91.1) U61.10 134.88,91.1 ; U67.6 16.59,30.62 ; P6.14 288.96,103 ; P6.14 286.6,103 ; P6.14 287.78,101.82 ; P6.14 287.78,104.18 ; 50.51,56.77 P21.8 ; P21.8 51.69,55.59 ; P21.8 51.69,57.95 ; P21.8 52.87,56.77 ; v1(385.64,72.04) P4.70 385.64,74.35 ; J4.42 26.48,74.35 ; P19.1_5 333.76,12.14 ; P19.1_5 332.51,10.9 ; P19.1_5 335,10.9 ; P19.1_5 333.76,9.65 ; J5.54 75.37,74.35 ; v1(123.77,39.63) U11.3 123.36,40.84 ; 394.53,75.85 P4.41 v1(394.53,78.16) ; U76.2 151.64,81.83 ; 344.36,75.85 P3.33 v1(344.36,78.16) ; 348.17,74.35 P3.22 v1(348.17,72.04) ; 50.51,82.17 P21.18 ; P21.18 51.69,80.99 ; P21.18 52.87,82.17 ; P21.18 51.69,83.35 ; 295.58,104.81 C264.2 295.58,105.98 ; P5.2 146.72,103 ; P5.2 145.54,101.82 ; P5.2 145.54,104.18 ; P5.2 144.36,103 ; 72.57,185.93 P14.8A 71.32,184.68 ; P5.12 159.42,103 ; P5.12 157.06,103 ; P5.12 158.24,101.82 ; P5.12 158.24,104.18 ; J4.74 16.32,74.35 ; v1(386.91,72.04) P4.66 386.91,74.35 ; 177.25,109.86 P26.1 179.62,109.86 ; 380.61,31.62 U69.13 379.27,31.62 ; 133.8,93.53 C268.2 133.8,94.7 ; P39.16 363.6,50.33 ; P39.16 363.6,47.97 ; P39.16 364.78,49.15 ; P39.16 362.42,49.15 ; 47.08,74.55 P20.6 ; P20.6 49.44,74.55 ; P20.6 48.26,75.73 ; P20.6 48.26,73.37 ; 140.33,37.65 C390.2 ; 109.6,82.54 C15.1 ; 34.8,3.89 J1.S ; J1.S 33.43,5.26 ; J1.S 36.17,5.26 ; J1.S 34.8,6.63 ; 273.04,81.08 R411.2 273.04,79.83 ; v1(380.56,72.04) P4.86 380.56,74.35 ; 225.29,40.82 C7.2 ; 363.6,78.45 P39.4 ; P39.4 362.42,79.63 ; P39.4 364.78,79.63 ; P39.4 363.6,80.81 ; 73.86,21.85 C279.2 72.69,21.85 ; 160.78,101.82 P5.14 ; P5.14 159.6,103 ; P5.14 161.96,103 ; P5.14 160.78,104.18 ; C34.2 126.57,40.74 ; 379.27,32.12 U69.14 380.61,32.12 ; 42.93,188.77 P14.SH1 ; P14.SH1 47.19,188.77 ; P14.SH1 45.06,190.91 ; P14.SH1 45.06,186.64 ; v1(136.86,91.6) U61.9 134.88,91.6 ; P40.16 368.21,77.09 ; P40.16 365.85,77.09 ; P40.16 367.03,78.27 ; P40.16 367.03,75.91 ; 164.62,21.75 PB1.1 167.16,21.75 ; 9.91,33.26 R533.2 9.91,32.02 ; 402.46,3.89 J2.S ; J2.S 401.09,5.26 ; J2.S 403.84,5.26 ; J2.S 402.46,6.63 ; 267.33,37.65 C47.2 ; 6.98,85.18 P32.11 ; P32.11 6.98,87.54 ; P32.11 8.17,86.36 ; P32.11 5.8,86.36 ; 395.8,74.35 P4.38 v1(395.8,72.04) ; PB2.2 157.86,21.75 ; PB2.2 156.59,23.02 ; PB2.2 155.32,21.75 ; 304.85,104.5 R350.2 304.28,103.87 ; P21.20 52.87,87.25 ; P21.20 50.51,87.25 ; P21.20 51.69,88.43 ; P21.20 51.69,86.07 ; v1(329.12,72.04) P3.82 329.12,74.35 ; v1(250.77,39.63) U12.3 250.36,40.84 ; v1(389.45,72.04) P4.58 389.45,74.35 ; 214.3,178.8 P15.GND4 ; P15.GND4 214.3,182.33 ; P15.GND4 216.07,180.56 ; P15.GND4 212.54,180.56 ; 323.51,109.86 P27.1 321.14,109.86 ; 214.64,43.19 R25.2 214.64,44.43 ; 51.69,65.75 P21.12 ; P21.12 51.69,68.11 ; P21.12 50.51,66.93 ; P21.12 52.87,66.93 ; 217.86,104.81 C266.2 217.86,105.98 ; v1(383.1,78.16) P4.77 383.1,75.85 ; 400.88,74.35 P4.22 v1(400.88,72.04) ; 393.26,75.85 P4.45 v1(393.26,78.16) ; 87.08,48.26 P37.2 ; P37.2 88.27,47.08 ; P37.2 89.45,48.26 ; P37.2 88.27,49.44 ; P6.2 273.72,103 ; P6.2 272.54,104.18 ; P6.2 272.54,101.82 ; P6.2 271.36,103 ; U40.8 124.59,95.14 ; U40.8 123.92,94.74 ; U40.8 123.24,95.14 ; 134.88,90.6 U61.11 v1(136.86,90.6) ; 109.16,57.49 C416.2 ; C416.2 108.25,58.55 ; C416.2 109.16,59.6 ; P20.14 49.44,54.23 ; P20.14 48.26,53.05 ; P20.14 48.26,55.41 ; P20.14 47.08,54.23 ; 336.74,74.35 P3.58 v1(336.74,72.04) ; U67.5 16.59,31.12 ; 78.38,185.93 P14.11A ; P14.11A 79.63,184.68 ; P14.11A 80.87,185.93 ; 208.66,15.91 C350.2 ; 259.72,37.65 C49.2 ; 335.47,74.35 P3.62 v1(335.47,72.04) ; v1(384.54,29.62) U69.8 383.59,29.22 ; 99.78,45.72 P37.11 ; P37.11 102.15,45.72 ; P37.11 100.97,46.9 ; P37.11 100.97,44.54 ; P21.16 51.69,78.27 ; P21.16 51.69,75.91 ; P21.16 52.87,77.09 ; P21.16 50.51,77.09 ; 47.08,79.63 P20.4 ; P20.4 48.26,78.45 ; P20.4 49.44,79.63 ; P20.4 48.26,80.81 ; v1(330.39,78.16) P3.77 330.39,75.85 ; 233.14,100.46 U37.8 232.46,100.85 ; J5.86 65.21,74.35 ; 338.01,75.85 P3.53 v1(338.01,78.16) ; J4.66 18.86,74.35 ; 147.57,37.18 C17.2 ; v1(346.9,72.04) P3.26 346.9,74.35 ; v1(391.99,78.16) P4.49 391.99,75.85 ; 146.9,103 P5.4 ; P5.4 148.08,101.82 ; P5.4 148.08,104.18 ; 287.64,180.03 P16.25 ; P16.25 287.64,182.14 ; P16.25 288.7,181.09 ; P16.25 286.59,181.09 ; 223.1,100.46 U36.8 222.43,100.85 ; 134.57,95.04 R354.2 134.57,96.29 ; 71.32,177.93 P14.8B ; P14.8B 70.08,179.17 ; P14.8B 71.32,180.42 ; P14.8B 72.57,179.17 ; v1(405.96,78.16) P4.5 405.96,75.85 ; 101.34,56.15 R593.2 101.34,57.39 ; 341.82,75.85 P3.41 v1(341.82,78.16) ; v1(325.31,72.04) P3.94 325.31,74.35 ; 336.78,21.83 C289.2 335.61,21.83 ; v1(402.15,72.04) P4.18 402.15,74.35 ; 15.92,29.72 U67.7 16.59,30.12 ; 12.95,31.62 U67.13 11.6,31.62 ; 128.9,78.35 C290.2 128.9,79.52 ; 327.85,74.35 P3.86 v1(327.85,72.04) ; 365.85,41.53 P40.2 ; P40.2 368.21,41.53 ; P40.2 367.03,42.71 ; P40.2 367.03,40.35 ; 350.88,21.83 C288.2 349.71,21.83 ; J4.18 34.1,74.35 ; 129.53,81.08 R408.2 129.53,79.83 ; v1(383.1,72.04) P4.78 383.1,74.35 ; 97.42,55.27 C418.2 98.3,54.52 ; 203.21,11.42 C345.2 203.21,12.59 ; 137.28,87.64 C371.2 137.28,86.47 ; 92.34,73.3 J5.2 91.88,74.35 ; 179.62,101.98 P22.1 177.25,101.98 ; v1(389.45,78.16) P4.57 389.45,75.85 ; 10.88,86.36 P32.7 ; P32.7 12.06,87.54 ; P32.7 13.25,86.36 ; P32.7 12.06,85.18 ; 163.32,101.82 P5.16 ; P5.16 162.14,103 ; P5.16 163.32,104.18 ; P5.16 164.5,103 ; 350.71,74.35 P3.14 v1(350.71,72.04) ; 200.38,19.88 C330.2 ; 379.29,74.35 P4.90 v1(379.29,72.04) ; 204.16,9.33 P9.B12 204.84,10.02 ; 266.36,83.47 U48.8 ; U48.8 267.04,83.87 ; U48.8 v1(267.84,83.47) ; v1(134.31,89.61) 134.82,89.1 U61.14 136.23,89.1 ; P14.SH3 94.18,180.77 ; P14.SH3 92.05,178.64 ; P14.SH3 89.92,180.77 ; P14.SH3 92.05,182.91 ; 195.2,35.72 C364.2 194.61,36.27 ; v1(263.86,90.6) U62.11 261.88,90.6 ; 149.04,180.56 P12.GND4 ; P12.GND4 150.8,182.33 ; P12.GND4 152.57,180.56 ; P12.GND4 150.8,178.8 ; v1(351.98,78.16) P3.9 351.98,75.85 ; 362.42,64.39 P39.10 ; P39.10 363.6,65.57 ; P39.10 364.78,64.39 ; P39.10 363.6,63.21 ; P32.5 15.79,86.36 ; P32.5 14.6,87.54 ; P32.5 14.6,85.18 ; P32.5 13.42,86.36 ; 206.87,24.6 C331.2 ; 80.45,75.85 J5.37 ; v1(378.65,78.16) P4.91 378.65,75.85 ; P14.22B 75.48,183.26 ; P14.22B 75.48,180.77 ; P14.22B 76.72,182.02 ; P14.22B 74.23,182.02 ; 384.37,74.35 P4.74 v1(384.37,72.04) ; J5.62 72.83,74.35 ; 47.08,49.15 P20.16 ; P20.16 48.26,47.97 ; P20.16 49.44,49.15 ; P20.16 48.26,50.33 ; 47.08,69.47 P20.8 ; P20.8 48.26,68.29 ; P20.8 49.44,69.47 ; P20.8 48.26,70.65 ; J4.78 15.05,74.35 ; v1(346.9,78.16) P3.25 346.9,75.85 ; J4.14 35.37,74.35 ; P20.20 48.26,40.17 ; P20.20 47.08,38.99 ; P20.20 48.26,37.81 ; 145.41,78.35 C291.2 145.41,79.52 ; v1(381.83,72.04) P4.82 381.83,74.35 ; 39.18,74.35 J4.2 39.64,73.3 ; J5.22 85.53,74.35 ; 394.53,74.35 P4.42 v1(394.53,72.04) ; 217.1,104.5 R351.2 217.1,103.25 ; P6.6 278.8,103 ; P6.6 277.62,101.82 ; P6.6 277.62,104.18 ; P6.6 276.44,103 ; C370.2 149.81,81.35 ; 198.49,79.31 P35.19 199.42,80.24 ; 122.14,103.1 C169.2 121.59,103.69 ; 79.18,75.85 J5.41 ; 189.53,37.53 U60.8 190.23,37.16 ; C349.2 211.28,16.45 ; C378.2 383.41,19.48 ; 300.83,100.46 U34.8 ; U34.8 300.15,100.85 ; U34.8 v1(301.7,100.85) ; C53.2 259.72,39.83 ; P40.20 367.03,88.43 ; P40.20 367.03,86.07 ; P40.20 365.85,87.25 ; P40.20 368.21,87.25 ; v1(397.07,78.16) P4.33 397.07,75.85 ; 388.18,74.35 P4.62 v1(388.18,72.04) ; 202.52,3.45 P9.SH4 ; P9.SH4 204.23,3.45 ; P9.SH4 203.38,4.61 ; J5.18 86.8,74.35 ; 274.57,37.18 C43.2 ; P35.3 209.58,80.24 ; U10.2 278.64,81.83 ; 353.25,75.85 P3.5 v1(353.25,78.16) ; P3.2 v1(354.52,72.04) ; P3.2 354.52,74.35 ; P3.2 354.98,73.3 ; v1(386.91,78.16) P4.65 386.91,75.85 ; J5.58 74.1,74.35 ; 11.6,31.12 U67.12 12.95,31.12 ; 141.85,39.77 R57.1 ; J5.38 80.45,74.35 ; v1(331.66,78.16) P3.73 331.66,75.85 ; 256.53,81.08 R410.2 256.53,79.83 ; 11.24,75.85 J4.89 ; U38.8 111.71,98.66 ; U38.8 111.03,99.06 ; U38.8 v1(110.03,98.66) ; P14.22A 76.72,188.77 ; P14.22A 74.23,188.77 ; P14.22A 75.48,190.02 ; 131.23,91.6 U61.8 v1(133.21,91.6) ; 200.38,18.86 C328.2 ; J5.82 66.48,74.35 ; 403.42,74.35 P4.14 v1(403.42,72.04) ; v1(336.74,78.16) P3.57 336.74,75.85 ; J5.26 84.26,74.35 ; 51.69,50.51 P21.6 ; P21.6 50.51,51.69 ; P21.6 52.87,51.69 ; P21.6 51.69,52.87 ; 203.84,14.72 C352.2 ; v1(390.72,72.04) P4.54 390.72,74.35 ; J5.14 88.07,74.35 ; 261.88,91.6 U62.9 v1(263.86,91.6) ; v1(393.26,72.04) P4.46 393.26,74.35 ; 323.51,94.11 P25.1 321.14,94.11 ; 115.95,127.94 C182.2 ; C182.2 114.9,128.84 ; C182.2 117.01,128.84 ; C182.2 115.95,129.74 ; J4.58 21.4,74.35 ; v1(331.66,72.04) P3.74 331.66,74.35 ; 261.88,89.6 U62.13 v1(263.86,89.6) ; 263.23,89.1 U62.14 v1(261.62,89.1) ; 329.12,75.85 P3.81 v1(329.12,78.16) ; 187.33,81.08 C428.2 ; C428.2 187.33,82.25 ; C428.2 v1(186.51,81.66) ; 321.14,86.36 P33.11 ; P33.11 322.33,85.18 ; P33.11 323.51,86.36 ; P33.11 322.33,87.54 ; v1(339.28,78.16) P3.49 339.28,75.85 ; C32.2 140.33,49.23 ; 104.91,56.15 R591.2 104.91,57.39 ; 379.29,75.85 P4.89 v1(379.29,78.48) ; 81.72,75.85 J5.33 ; 211.7,22.08 C324.2 ; 195.2,39.85 C365.2 194.61,39.3 ; J4.70 17.59,74.35 ; J4.6 37.91,74.35 ; 385.64,75.85 P4.69 v1(385.64,78.16) ; 398.34,74.35 P4.30 v1(398.34,72.04) ; 203.3,16.32 C358.2 ; 86.8,75.85 J5.17 ; 264.28,86.47 C372.2 264.28,87.64 ; 84.26,75.85 J5.25 ; 51.69,60.67 P21.10 ; P21.10 52.87,61.85 ; P21.10 50.51,61.85 ; P21.10 51.69,63.03 ; U7.7 v1(218.95,45.76) ; J5.70 70.29,74.35 ; C357.2 211.7,24.27 ; 384.37,75.85 P4.73 v1(384.37,78.16) ; 23.94,75.85 J4.49 ; 343.09,74.35 P3.38 v1(343.09,72.04) ; J4.62 20.13,74.35 ; J5.78 67.75,74.35 ; J5.30 82.99,74.35 ; P35.5 208.31,80.24 ; U45.8 124.2,83.47 ; U45.8 123.53,83.87 ; U45.8 122.85,83.47 ; 353.25,74.35 P3.6 v1(353.25,72.04) ; v1(404.69,78.16) P4.9 404.69,75.85 ; J4.34 29.02,74.35 ; 296.04,21.75 PB3.2 298.58,21.75 ; 325.31,75.85 P3.93 v1(325.31,78.48) ; 227.89,104.81 C75.2 227.89,105.98 ; 128.56,99.06 U39.8 127.89,98.66 ; C25.2 132.72,39.83 ; 344.36,74.35 P3.34 v1(344.36,72.04) ; J4.94 9.97,74.35 ; v1(399.61,72.04) P4.26 399.61,74.35 ; 82.99,75.85 J5.29 ; v1(404.69,72.04) P4.10 404.69,74.35 ; J4.10 36.64,74.35 ; J5.90 63.94,74.35 ; v1(345.63,72.04) P3.30 345.63,74.35 ; v1(378.02,78.48) P4.93 378.02,75.85 ; C58.2 267.33,49.23 ; C267.2 116.28,94.7 ; 267.33,47.04 C60.2 ; v1(403.42,78.16) P4.13 403.42,75.85 ; P9.GND1 205.65,10.02 ; 200.38,17.84 C327.2 ; 140.33,47.04 C42.2 ; 15.05,75.85 J4.77 ; 210.19,10.24 R480.2 ; R480.2 210.19,11.48 ; R480.2 209.62,10.86 ; C329.2 212.32,17.72 ; J5.10 89.34,74.35 ; v1(348.17,78.16) P3.21 348.17,75.85 ; 13.2,13.64 C375.2 13.75,13.06 ; 268.85,39.77 R89.1 ; 264.91,87.96 R525.2 ; 16.32,75.85 J4.73 ; 132.72,37.65 C21.2 ; C33.2 132.72,49.23 ; 77.91,75.85 J5.45 ; 89.34,75.85 J5.9 ; 137.91,87.96 R524.2 ; J4.38 27.75,74.35 ; 9.97,75.85 J4.93 ; J4.82 13.78,74.35
  BOTTOM w0.305: 76.4,10.92 P18.1_3 76.38,12.01 76.81,12.44 ; 76.4,10.92 77.55,10.92 77.85,10.62 77.85,10.16 78.99,9.02 79.59,9.02 P18.1_6 82.49,8.08 D5.3 85.45,8.13 ; 76.4,10.92 76.4,7.73 78.36,5.78 84.78,5.78 85.45,6.45 85.45,8.13 ; U13.3 219.32,80.64 v1(219.71,81.03) ; 348.36,8.1 D7.3 345.4,8.05 P19.1_6 342.51,8.99 341.91,8.99 340.77,10.13 340.77,10.59 340.46,10.9 P19.1_3 ; 348.36,8.1 348.36,6.42 347.69,5.75 341.27,5.75 339.34,7.68 339.34,10.85 P19.1_3 ; 348.36,8.1 348.36,12.37 348.31,12.42 ; 244.6,23.82 U64.3 ; U64.3 v1(245.45,24.24) ; U64.3 243.88,24.24 ; 339.73,12.42 339.34,12.8 339.34,17.6 339.34,17.6 P19.2_3 ; 339.73,12.42 339.29,11.99 P19.1_3 ; 339.73,12.42 348.31,12.42 ; 76.81,12.44 76.38,12.88 P18.2_3 ; 76.81,12.44 85.39,12.44 ; P18.2_3 77.48,17.68 77.72,17.44 77.72,16.89 78.61,16 79.36,16 P18.2_6 82.51,14.83 D6.3 82.56,14.88 85.45,14.88 ; P18.2_3 76.38,18.71 76.68,19.01 82.97,19.01 85.45,16.54 85.45,14.88 ; 217.09,46.18 U7.7 216.01,45.76 ; 85.45,14.88 85.45,12.49 85.39,12.44 ; P19.2_3 340.4,17.65 340.64,17.41 340.64,16.87 341.53,15.98 342.28,15.98 P19.2_6 345.43,14.81 D8.3 345.48,14.86 348.36,14.86 ; P19.2_3 340.5,18.86 346.01,18.86 348.36,16.51 348.36,14.86 ; 85.45,8.13 85.45,12.39 85.39,12.44 ; 203.39,10.4 R482.2 ; R482.2 203.39,11.32 ; R482.2 v1(202.7,10.86) ; 348.36,14.86 348.36,12.47 348.31,12.42 ; D13.2 v1(207.64,15.56) ; U67.8 v1(16.87,29.62)
  BOTTOM w0.508: U6.2 v1(290.45,27.64) ; R408.2 v1(130.23,80.45) ; C71.2 222.25,71.69 v1(222.25,72.9) ; C350.2 C348.2 C349.2 210.69,15.28 v1(210.7,15.28) ; v1(16.49,18.9) C373.2 15.74,16.67 M1.6 ; C269.2 v1(117.79,99.68) ; R411.2 v1(273.74,80.45) ; R349.2 v1(294.05,103.87) ; R505.2 R504.2 v1(24.77,116.46) ; R505.2 v1(23.87,114.36) ; R505.2 R506.2 R507.2 ; C264.2 v1(294.83,105.4) ; Y2.2 273.46,37.73 C43.2 v1(275.49,37.73) ; PB3.1 v1(292.89,20.15) ; PB1.1 v1(165.89,20.15) ; R89.1 269.55,40.39 ; C345.2 v1(202.53,12) ; R507.2 R508.2 v1(24.77,109.98) ; R507.2 v1(23.87,112.08) ; v1(304.85,103) R350.2 ; C279.2 v1(73.28,21.18) ; C75.2 v1(227.14,105.4) ; C370.2 v1(149.22,80.48) ; C278.2 v1(87.38,21.18) ; R25.2 v1(213.86,43.81) ; v1(211.96,16.95) 211.73,17.17 C329.2 ; C340.2 203.84,17.34 C358.2 C352.2 v1(203.17,15.3) ; C5.2 v1(163.45,32.75) ; R533.2 v1(9.14,32.64) ; C60.2 v1(268,47.63) ; C365.2 v1(195.99,39.3) ; PB2.1 v1(152.17,20.15) ; v1(142.74,40.39) 142.73,40.39 R57.1 ; R36.2 v1(101.09,88.48) ; U76.2 v1(151.64,79.08) ; C169.2 v1(121.59,102.32) ; R353.2 v1(117.94,95.66) ; v1(200.92,17.13) C327.2 C328.2 C330.2 C337.2 v1(200.92,21.6) ; C74.2 v1(304.87,105.4) ; C364.2 v1(195.99,36.27) ; C70.2 216.41,71.69 v1(216.41,72.9) ; R351.2 v1(216.32,103.87) ; R524.2 v1(137.91,89.6) ; C2.2 v1(162.94,23.21) ; R595.2 v1(231.14,56.77) ; R525.2 v1(264.91,89.59) ; v1(120,119.65) 119.08,119.65 C185.2 ; S14.2 v1(244.22,23.15) ; C171.2 v1(121.59,105.67) ; C267.2 v1(117.16,94.12) ; R410.2 v1(257.23,80.45) ; C289.2 v1(336.19,21.15) ; 107.82,83.09 C15.1 v1(110.39,83.09) ; C422.2 v1(237.39,58.55) ; C266.2 v1(217.11,105.4) ; C32.2 v1(141,48.64) ; R593.2 v1(102.11,56.77) ; R355.2 v1(116.96,98.14) ; R51.2 v1(99.88,86.74) ; PB2.2 v1(156.59,20.15) ; C53.2 v1(259.08,39.25) ; C383.2 v1(247.95,26.54) ; C295.2 v1(9.93,34.16) ; v1(227.13,103) R352.2 ; C290.2 v1(129.57,78.93) ; U5.2 v1(163.45,27.64) ; C324.2 212.46,22.67 ; C324.2 211.73,22.64 C334.2 ; C324.2 C357.2 212.4,23.69 v1(212.59,23.88) ; C7.2 v1(226.17,41.4) ; R597.2 v1(229.11,56.77) ; C24.2 v1(276.23,80.48) ; PB4.2 v1(283.59,20.15) ; C291.2 v1(146.08,78.93) ; C371.2 v1(137.95,87.06) ; C424.2 v1(226.38,55.27) ; C27.2 v1(140.97,39.25) ; R591.2 v1(104.14,56.77) ; C292.2 v1(256.57,78.93) ; v1(104.4,90.03) C14.1 104.4,87.89 ; C4.2 v1(289.94,23.21) ; v1(148.49,37.73) C17.2 146.46,37.73 Y1.2 ; R34.2 v1(98.17,91.31) ; C375.2 13.2,11.67 M1.2 ; PB4.1 v1(279.17,20.15) ; C390.2 v1(140.97,38.23) ; C382.2 v1(377.59,34.16) ; R354.2 v1(135.47,95.66) ; C3.2 v1(290.96,23.21) ; C33.2 v1(132.05,48.64) ; C35.2 v1(132.05,47.63) ; C394.2 v1(239.67,25.53) ; PB3.2 v1(297.31,20.15) ; M2.6 383.41,16.67 C378.2 v1(384.15,18.9) ; M2.2 380.87,11.67 C379.2 ; C21.2 v1(132.08,38.23) ; C47.2 v1(267.97,38.23) ; R534.2 v1(376.8,32.64) ; C51.2 v1(267.97,39.25) ; C6.2 v1(290.45,32.75) ; C293.2 v1(273.08,78.93) ; R119.2 v1(217.82,78.83) ; C416.2 v1(110.39,58.55) ; C418.2 v1(99.38,55.27) ; R22.2 v1(225.29,43.63) ; R117.2 v1(220.84,77.26) ; C34.2 v1(125.38,40.74) ; PB1.2 v1(170.31,20.15) ; C49.2 v1(259.08,38.23) ; C58.2 v1(268,48.64) ; C25.2 v1(132.08,39.25) ; U10.2 v1(278.64,79.46) ; R409.2 v1(146.74,80.45) ; C268.2 v1(134.68,94.12) ; C68.2 v1(252.38,40.74) ; C288.2 v1(350.29,21.15) ; C1.2 v1(163.96,23.21) ; C61.2 v1(259.05,47.63) ; C372.2 v1(264.95,87.06) ; C42.2 v1(141,47.63)
  BOTTOM w1.016: 330.45,191.13 P7.2 ; P7.2 332.02,192.69 ; P7.2 328.89,192.69 ; P7.3 327.32,189.69 ; P7.3 325.75,191.25 ; P7.3 324.19,189.69 ; P7.3 325.75,188.13
  vias: v1(2.79,185.67) v1(2.79,180.59) v1(2.79,175.51) v1(2.79,170.43) v1(2.79,165.35) v1(2.79,160.27) v1(2.79,155.19) v1(2.79,150.11) v1(2.79,145.03) v1(2.79,139.95) v1(2.79,134.87) v1(2.79,129.79) v1(2.79,124.71) v1(2.79,119.63) v1(2.79,114.55) v1(2.79,109.47) v1(2.79,104.39) v1(2.79,99.31) v1(2.79,94.23) v1(2.79,89.15) v1(2.79,84.07) v1(2.79,78.99) v1(2.79,73.91) v1(2.79,68.83) v1(2.79,63.75) v1(2.79,58.67) v1(2.79,53.59) v1(2.79,48.51) v1(2.79,43.43) v1(2.79,38.35) v1(2.79,33.27) v1(2.79,28.19) v1(2.79,23.11) v1(2.79,18.03) v1(2.79,12.95) v1(5.33,188.21) v1(5.33,183.13) v1(5.33,178.05) v1(5.33,172.97) v1(5.33,167.89) v1(5.33,162.81) v1(5.33,157.73) v1(5.33,152.65) v1(5.33,147.57) v1(5.33,142.49) v1(5.33,137.41) v1(5.33,132.33) v1(5.33,127.25) v1(5.33,122.17) v1(5.33,117.09) v1(5.33,112.01) v1(5.33,106.93) v1(5.33,101.85) v1(5.33,91.69) v1(5.33,61.21) v1(5.33,56.13) v1(5.33,51.05) v1(5.33,45.97) v1(5.33,40.89) v1(5.33,35.81) v1(5.33,30.73) v1(5.33,25.65) v1(5.33,20.57) v1(5.33,15.49) v1(5.33,10.41) v1(5.33,5.33) v1(6.26,68.17) v1(7.25,75.72) v1(7.87,190.75) v1(7.87,185.67) v1(7.87,180.59) v1(7.87,175.51) v1(7.87,170.43) v1(7.87,165.35) v1(7.87,160.27) v1(7.87,155.19) v1(7.87,150.11) v1(7.87,145.03) v1(7.87,139.95) v1(7.87,134.87) v1(7.87,129.79) v1(7.87,124.71) v1(7.87,119.63) v1(7.87,114.55) v1(7.87,109.47) v1(7.87,104.39) v1(7.87,99.31) v1(7.87,94.23) v1(7.87,78.99) v1(7.87,63.75) v1(7.87,58.67) v1(7.87,53.59) v1(7.87,48.51) v1(7.87,43.43) v1(7.87,38.35) v1(7.87,33.27) v1(7.87,28.19) v1(7.87,23.11) v1(7.87,18.03) v1(7.87,2.79) v1(10.41,193.29) v1(10.41,188.21) v1(10.41,183.13) v1(10.41,178.05) v1(10.41,172.97) v1(10.41,167.89) v1(10.41,162.81) v1(10.41,157.73) v1(10.41,152.65) v1(10.41,147.57) v1(10.41,142.49) v1(10.41,137.41) v1(10.41,132.33) v1(10.41,127.25) v1(10.41,122.17) v1(10.41,117.09) v1(10.41,112.01) v1(10.41,106.93) v1(10.41,101.85) v1(10.41,96.77) v1(10.41,61.21) v1(10.41,56.13) v1(10.41,51.05) v1(10.41,45.97) v1(10.41,40.89) v1(10.41,35.81) v1(10.41,30.73) v1(10.41,20.57) v1(10.41,5.33) v1(10.78,84.96) v1(10.94,69.42) v1(12.95,190.75) v1(12.95,185.67) v1(12.95,180.59) v1(12.95,175.51) v1(12.95,170.43) v1(12.95,165.35) v1(12.95,160.27) v1(12.95,155.19) v1(12.95,150.11) v1(12.95,145.03) v1(12.95,139.95) v1(12.95,134.87) v1(12.95,129.79) v1(12.95,124.71) v1(12.95,119.63) v1(12.95,114.55) v1(12.95,109.47) v1(12.95,104.39) v1(12.95,99.31) v1(12.95,89.15) v1(12.95,63.75) v1(12.95,58.67) v1(12.95,53.59) v1(12.95,48.51) v1(12.95,43.43) v1(12.95,38.35) v1(12.95,23.11) v1(12.95,18.03) v1(12.95,2.79) v1(13.81,19.69) v1(14.03,13.08) v1(15.49,193.29) v1(15.49,188.21) v1(15.49,183.13) v1(15.49,178.05) v1(15.49,172.97) v1(15.49,167.89) v1(15.49,162.81) v1(15.49,157.73) v1(15.49,152.65) v1(15.49,147.57) v1(15.49,142.49) v1(15.49,137.41) v1(15.49,132.33) v1(15.49,127.25) v1(15.49,122.17) v1(15.49,117.09) v1(15.49,112.01) v1(15.49,106.93) v1(15.49,101.85) v1(15.49,91.69) v1(15.49,61.21) v1(15.49,56.13) v1(15.49,51.05) v1(15.49,45.97) v1(15.49,40.89) v1(15.49,35.81) v1(15.49,5.33) v1(15.79,69.42) v1(17.74,74.83) v1(18.03,190.75) v1(18.03,185.67) v1(18.03,180.59) v1(18.03,175.51) v1(18.03,170.43) v1(18.03,165.35) v1(18.03,160.27) v1(18.03,155.19) v1(18.03,150.11) v1(18.03,145.03) v1(18.03,139.95) v1(18.03,134.87) v1(18.03,129.79) v1(18.03,124.71) v1(18.03,119.63) v1(18.03,63.75) v1(18.03,58.67) v1(18.03,53.59) v1(18.03,48.51) v1(18.03,43.43) v1(18.03,38.35) v1(18.03,33.27) v1(18.03,18.03) v1(18.03,12.95) v1(18.03,2.79) v1(18.41,82.88) v1(20.57,193.29) v1(20.57,188.21) v1(20.57,183.13) v1(20.57,178.05) v1(20.57,172.97) v1(20.57,167.89) v1(20.57,162.81) v1(20.57,157.73) v1(20.57,152.65) v1(20.57,147.57) v1(20.57,142.49) v1(20.57,137.41) v1(20.57,132.33) v1(20.57,127.25) v1(20.57,122.17) v1(20.57,112.01) v1(20.57,106.93) v1(20.57,101.85) v1(20.57,96.77) v1(20.57,91.69) v1(20.57,81.53) v1(20.57,61.21) v1(20.57,56.13) v1(20.57,51.05) v1(20.57,45.97) v1(20.57,40.89) v1(20.57,35.81) v1(20.57,20.57) v1(20.57,10.41) v1(20.57,5.33) v1(23.11,190.75) v1(23.11,185.67) v1(23.11,180.59) v1(23.11,175.51) v1(23.11,170.43) v1(23.11,165.35) v1(23.11,160.27) v1(23.11,155.19) v1(23.11,150.11) v1(23.11,145.03) v1(23.11,139.95) v1(23.11,134.87) v1(23.11,129.79) v1(23.11,124.71) v1(23.11,114.55) v1(23.11,109.47) v1(23.11,104.39) v1(23.11,99.31) v1(23.11,94.23) v1(23.11,89.15) v1(23.11,84.07) v1(23.11,78.99) v1(23.11,63.75) v1(23.11,58.67) v1(23.11,53.59) v1(23.11,48.51) v1(23.11,43.43) v1(23.11,38.35) v1(23.11,28.19) v1(23.11,23.11) v1(23.11,18.03) v1(23.11,12.95) v1(23.11,2.79) v1(25.08,75.51) v1(25.24,16.28) v1(25.65,193.29) v1(25.65,188.21) v1(25.65,183.13) v1(25.65,178.05) v1(25.65,172.97) v1(25.65,167.89) v1(25.65,162.81) v1(25.65,157.73) v1(25.65,152.65) v1(25.65,147.57) v1(25.65,142.49) v1(25.65,137.41) v1(25.65,132.33) v1(25.65,127.25) v1(25.65,117.09) v1(25.65,106.93) v1(25.65,96.77) v1(25.65,91.69) v1(25.65,86.61) v1(25.65,81.53) v1(25.65,61.21) v1(25.65,56.13) v1(25.65,51.05) v1(25.65,45.97) v1(25.65,40.89) v1(25.65,30.73) v1(25.65,25.65) v1(25.65,20.57) v1(25.65,5.33) v1(27.55,63.86) v1(28.19,190.75) v1(28.19,185.67) v1(28.19,180.59) v1(28.19,175.51) v1(28.19,170.43) v1(28.19,165.35) v1(28.19,160.27) v1(28.19,155.19) v1(28.19,150.11) v1(28.19,145.03) v1(28.19,139.95) v1(28.19,134.87) v1(28.19,129.79) v1(28.19,124.71) v1(28.19,94.23) v1(28.19,89.15) v1(28.19,84.07) v1(28.19,78.99) v1(28.19,33.27) v1(28.19,28.19) v1(28.19,23.11) v1(28.19,7.87) v1(28.19,2.79) v1(28.94,109.09) v1(29.72,115) v1(29.72,114.24) v1(29.72,113.47) v1(30.48,115) v1(30.48,114.24) v1(30.48,113.47) v1(30.73,193.29) v1(30.73,188.21) v1(30.73,183.13) v1(30.73,178.05) v1(30.73,172.97) v1(30.73,167.89) v1(30.73,162.81) v1(30.73,157.73) v1(30.73,152.65) v1(30.73,147.57) v1(30.73,142.49) v1(30.73,137.41) v1(30.73,132.33) v1(30.73,127.25) v1(30.73,96.77) v1(30.73,91.69) v1(30.73,86.61) v1(30.73,81.53) v1(30.73,61.21) v1(30.73,56.13) v1(30.73,51.05) v1(30.73,45.97) v1(30.73,40.89) v1(30.73,35.81) v1(30.73,30.73) v1(30.73,25.65) v1(30.73,15.49) v1(30.73,10.41) v1(30.73,5.33) v1(31.24,115) v1(31.24,114.24) v1(31.24,113.47) v1(31.33,64.24) v1(32.37,108.46) v1(32.48,112.25) v1(33.27,190.75) v1(33.27,185.67) v1(33.27,180.59) v1(33.27,175.51) v1(33.27,170.43) v1(33.27,165.35) v1(33.27,160.27) v1(33.27,155.19) v1(33.27,150.11) v1(33.27,145.03) v1(33.27,139.95) v1(33.27,134.87) v1(33.27,129.79) v1(33.27,124.71) v1(33.27,104.39) v1(33.27,99.31) v1(33.27,94.23) v1(33.27,89.15) v1(33.27,84.07) v1(33.27,78.99) v1(33.27,58.67) v1(33.27,53.59) v1(33.27,48.51) v1(33.27,43.43) v1(33.27,38.35) v1(33.27,33.27) v1(33.27,23.11) v1(33.27,18.03) v1(33.27,12.95) v1(33.27,7.87) v1(33.27,2.79) v1(33.39,109.35) v1(35.81,193.29) v1(35.81,188.21) v1(35.81,183.13) v1(35.81,178.05) v1(35.81,172.97) v1(35.81,167.89) v1(35.81,162.81) v1(35.81,157.73) v1(35.81,152.65) v1(35.81,147.57) v1(35.81,142.49) v1(35.81,137.41) v1(35.81,132.33) v1(35.81,127.25) v1(35.81,106.93) v1(35.81,101.85) v1(35.81,96.77) v1(35.81,91.69) v1(35.81,86.61) v1(35.81,81.53) v1(35.81,56.13) v1(35.81,51.05) v1(35.81,45.97) v1(35.81,40.89) v1(35.81,35.81) v1(35.81,30.73) v1(35.81,25.65) v1(36.49,5.31) v1(37.43,25.2) v1(38.35,190.75) v1(38.35,185.67) v1(38.35,180.59) v1(38.35,175.51) v1(38.35,170.43) v1(38.35,165.35) v1(38.35,160.27) v1(38.35,155.19) v1(38.35,150.11) v1(38.35,145.03) v1(38.35,139.95) v1(38.35,134.87) v1(38.35,129.79) v1(38.35,124.71) v1(38.35,114.55) v1(38.35,104.39) v1(38.35,99.31) v1(38.35,94.23) v1(38.35,89.15) v1(38.35,84.07) v1(38.35,78.99) v1(38.35,58.67) v1(38.35,53.59) v1(38.35,48.51) v1(38.35,43.43) v1(38.35,38.35) v1(38.35,33.27) v1(38.35,12.95) v1(38.35,2.79) v1(39.92,19.28) v1(40.89,193.29) v1(40.89,188.21) v1(40.89,183.13) v1(40.89,178.05) v1(40.89,172.97) v1(40.89,167.89) v1(40.89,162.81) v1(40.89,157.73) v1(40.89,152.65) v1(40.89,147.57) v1(40.89,142.49) v1(40.89,137.41) v1(40.89,132.33) v1(40.89,127.25) v1(40.89,122.17) v1(40.89,106.93) v1(40.89,101.85) v1(40.89,96.77) v1(40.89,56.13) v1(40.89,51.05) v1(40.89,45.97) v1(40.89,40.89) v1(40.89,35.81) v1(40.89,30.73) v1(40.89,25.65) v1(40.89,15.49) v1(40.89,10.41) v1(40.89,5.33) v1(41.21,69.44) v1(41.47,93.24) v1(41.44,89.18) v1(41.42,84.12) v1(41.47,74.78) v1(41.59,77.44) v1(43.43,190.75) v1(43.43,185.67) v1(43.43,175.51) v1(43.43,170.43) v1(43.43,165.35) v1(43.43,160.27) v1(43.43,155.19) v1(43.43,150.11) v1(43.43,145.03) v1(43.43,139.95) v1(43.43,134.87) v1(43.43,129.79) v1(43.43,124.71) v1(43.43,119.63) v1(43.43,114.55) v1(43.43,104.39) v1(43.43,99.31) v1(43.43,53.59) v1(43.43,48.51) v1(43.43,43.43) v1(43.43,38.35) v1(43.43,33.27) v1(43.43,28.19) v1(43.43,23.11) v1(43.43,18.03) v1(43.43,12.95) v1(43.43,7.87) v1(44.67,64.44) v1(45.97,193.29) v1(45.97,183.13) v1(45.97,178.05) v1(45.97,172.97) v1(45.97,167.89) v1(45.97,162.81) v1(45.97,157.73) v1(45.97,152.65) v1(45.97,147.57) v1(45.97,142.49) v1(45.97,137.41) v1(45.97,132.33) v1(45.97,127.25) v1(45.97,122.17) v1(45.97,117.09) v1(45.97,106.93) v1(45.97,101.85) v1(45.97,96.77) v1(45.97,71.37) v1(45.97,61.21) v1(45.97,51.05) v1(45.97,45.97) v1(45.97,40.89) v1(45.97,35.81) v1(45.97,30.73) v1(45.97,25.65) v1(45.97,20.57) v1(45.97,15.49) v1(45.97,10.41) v1(45.97,5.33) v1(45.99,59.92) v1(46.37,93.37) v1(46.37,62.56) v1(48.51,190.75) v1(48.51,185.67) v1(48.51,180.59) v1(48.51,175.51) v1(48.51,170.43) v1(48.51,165.35) v1(48.51,160.27) v1(48.51,155.19) v1(48.51,150.11) v1(48.51,145.03) v1(48.51,139.95) v1(48.51,134.87) v1(48.51,129.79) v1(48.51,124.71) v1(48.51,119.63) v1(48.51,114.55) v1(48.51,104.39) v1(48.51,99.31) v1(48.51,33.27) v1(48.51,28.19) v1(48.51,23.11) v1(48.51,18.03) v1(48.51,12.95) v1(48.51,7.87) v1(48.51,2.79) v1(48.6,95.4) v1(48.88,37.44) v1(49.7,41.05) v1(49.98,84.35) v1(49.92,52.27) v1(50.03,48.18) v1(50.05,45.9) v1(50.1,82.12) v1(50.38,90.27) v1(50.69,97.33) v1(50.89,42.8) v1(51.05,193.29) v1(51.05,183.13) v1(51.05,172.97) v1(51.05,167.89) v1(51.05,162.81) v1(51.05,157.73) v1(51.05,152.65) v1(51.05,147.57) v1(51.05,142.49) v1(51.05,137.41) v1(51.05,132.33) v1(51.05,127.25) v1(51.05,122.17) v1(51.05,117.09) v1(51.05,106.93) v1(51.05,101.85) v1(51.05,35.81) v1(51.05,30.73) v1(51.05,25.65) v1(51.05,20.57) v1(51.05,15.49) v1(51.05,10.41) v1(51.05,5.33) v1(52.74,92.41) v1(53.18,65.25) v1(53.3,71.35) v1(53.33,60.12) v1(53.38,56.39) v1(53.59,190.75) v1(53.59,119.63) v1(53.59,114.55) v1(53.59,104.39) v1(53.59,99.31) v1(53.59,84.07) v1(53.59,78.99) v1(53.59,63.75) v1(53.59,58.67) v1(53.59,43.43) v1(53.59,38.35) v1(53.59,33.27) v1(53.59,28.19) v1(53.59,23.11) v1(53.59,18.03) v1(53.59,12.95) v1(53.59,7.87) v1(54.47,97.49) v1(55.08,80.37) v1(55.11,92.41) v1(55.18,89.38) v1(56.13,172.97) v1(56.13,167.89) v1(56.13,162.81) v1(56.13,157.73) v1(56.13,152.65) v1(56.13,147.57) v1(56.13,142.49) v1(56.13,137.41) v1(56.13,132.33) v1(56.13,127.25) v1(56.13,122.17) v1(56.13,117.09) v1(56.13,106.93) v1(56.13,101.85) v1(56.13,66.29) v1(56.13,61.21) v1(56.13,45.97) v1(56.13,40.89) v1(56.13,35.81) v1(56.13,30.73) v1(56.13,25.65) v1(56.13,20.57) v1(56.13,15.49) v1(56.13,10.41) v1(57.04,50.88) v1(58.67,175.51) v1(58.67,170.43) v1(58.67,165.35) v1(58.67,160.27) v1(58.67,155.19) v1(58.67,150.11) v1(58.67,145.03) v1(58.67,139.95) v1(58.67,134.87) v1(58.67,129.79) v1(58.67,124.71) v1(58.67,119.63) v1(58.67,114.55) v1(58.67,104.39) v1(58.67,99.31) v1(58.67,48.51) v1(58.67,43.43) v1(58.67,38.35) v1(58.67,33.27) v1(58.67,28.19) v1(58.67,23.11) v1(58.67,18.03) v1(58.67,12.95) v1(58.67,7.87) v1(58.67,2.79) v1(58.79,177.42) v1(58.81,92.53) v1(59.7,72.62) v1(59.88,77.14) v1(60.06,61.95) v1(61.1,28.27) v1(61.21,127.25) v1(61.21,122.17) v1(61.21,117.09) v1(61.21,112.01) v1(61.21,101.85) v1(61.21,91.69) v1(61.21,86.61) v1(61.21,51.05) v1(61.21,45.97) v1(61.21,40.89) v1(61.21,35.81) v1(61.21,30.73) v1(61.21,25.65) v1(61.21,20.57) v1(61.21,15.49) v1(61.21,10.41) v1(61.21,5.33) v1(61.74,55.63) v1(61.79,29.77) v1(62.04,60.55) v1(62.07,58.17) v1(62.7,67.46) v1(63.23,79.6) v1(63.75,180.59) v1(63.75,175.51) v1(63.75,165.35) v1(63.75,160.27) v1(63.75,155.19) v1(63.75,150.11) v1(63.75,145.03) v1(63.75,139.95) v1(63.75,134.87) v1(63.75,124.71) v1(63.75,119.63) v1(63.75,114.55) v1(63.75,109.47) v1(63.75,99.31) v1(63.75,48.51) v1(63.75,43.43) v1(63.75,38.35) v1(63.75,33.27) v1(63.75,29.69) v1(63.75,28.19) v1(63.75,23.11) v1(63.75,12.95) v1(63.75,2.79) v1(64.76,55.68) v1(66,59.39) v1(66.03,57) v1(66.1,67.28) v1(66.29,122.17) v1(66.29,117.09) v1(66.29,112.01) v1(66.29,106.93) v1(66.29,91.69) v1(66.29,51.05) v1(66.29,45.97) v1(66.29,40.89) v1(66.29,35.81) v1(66.29,30.73) v1(66.29,25.65) v1(66.29,20.57) v1(66.29,10.41) v1(66.29,5.33) v1(67.83,64.34) v1(68.57,177.04) v1(68.83,160.27) v1(68.83,155.19) v1(68.83,150.11) v1(68.83,145.03) v1(68.83,124.71) v1(68.82,119.38) v1(68.83,114.55) v1(68.82,110.24) v1(68.83,104.39) v1(68.83,48.51) v1(68.83,43.43) v1(68.83,38.35) v1(68.83,33.27) v1(68.83,23.11) v1(68.83,18.03) v1(68.83,12.95) v1(68.83,2.79) v1(69.79,67.28) v1(70.17,60.66) v1(70.09,55.65) v1(70.22,58.17) v1(70.78,64.36) v1(71.11,51.82) v1(71.37,188.21) v1(71.36,177.04) v1(71.37,167.89) v1(71.37,157.73) v1(71.37,152.65) v1(71.37,147.57) v1(71.37,132.33) v1(71.37,45.97) v1(71.37,40.89) v1(71.37,30.73) v1(71.37,20.57) v1(71.37,5.33) v1(72.3,64.39) v1(72.51,55.63) v1(72.68,67.28) v1(73.91,165.35) v1(73.91,145.03) v1(73.91,139.95) v1(73.91,134.87) v1(73.91,124.71) v1(73.91,119.63) v1(73.91,114.55) v1(73.91,109.47) v1(73.91,104.39) v1(73.91,48.51) v1(73.91,43.43) v1(73.91,33.27) v1(73.91,29.69) v1(73.91,28.19) v1(73.91,12.95) v1(73.91,2.79) v1(74.16,188.09) v1(74.28,151.89) v1(75.27,59.41) v1(75.27,57) v1(75.35,16.38) v1(75.55,184.66) v1(75.93,21.67) v1(76.45,127.25) v1(76.45,91.69) v1(76.45,86.61) v1(76.45,81.53) v1(76.45,45.97) v1(76.45,40.89) v1(76.45,30.73) v1(76.45,5.33) v1(76.54,64.34) v1(76.52,51.89) v1(76.82,177.04) v1(77.2,162.43) v1(77.99,55.7) v1(78.25,20.27) v1(78.55,75.13) v1(78.99,180.59) v1(78.99,139.95) v1(78.99,129.79) v1(78.99,124.71) v1(78.99,114.55) v1(78.99,104.39) v1(78.99,84.07) v1(78.99,48.51) v1(78.99,43.43) v1(78.99,33.27) v1(78.99,29.69) v1(78.99,28.19) v1(78.99,23.11) v1(78.99,2.79) v1(79.19,60.66) v1(79.21,55.68) v1(79.31,58.17) v1(80,64.97) v1(80.48,75.13) v1(80.99,21.67) v1(81.47,5.16) v1(81.53,162.81) v1(81.53,157.73) v1(81.53,132.33) v1(81.53,106.93) v1(81.53,86.61) v1(81.53,81.53) v1(81.53,51.05) v1(81.53,45.97) v1(81.53,40.89) v1(81.53,30.73) v1(81.53,25.65) v1(81.78,56.85) v1(81.8,55.7) v1(81.9,116.84) v1(82.16,122.05) v1(82.64,65.1) v1(83.07,61.7) v1(83.58,20.24) v1(84.07,180.59) v1(84.07,165.35) v1(84.07,145.03) v1(84.07,124.71) v1(84.07,114.55) v1(84.07,104.39) v1(84.07,84.07) v1(84.07,53.59) v1(84.07,48.51) v1(84.07,43.43) v1(84.07,33.27) v1(84.07,23.11) v1(84.07,2.79) v1(84.7,65.1) v1(84.9,87.25) v1(84.95,61.7) v1(85.21,17.86) v1(85.84,162.43) v1(86.09,12.67) v1(86.2,10.67) v1(86.48,65.07) v1(86.61,157.73) v1(86.61,137.41) v1(86.61,132.33) v1(86.61,122.17) v1(86.61,117.09) v1(86.61,112.01) v1(86.61,106.93) v1(86.61,96.77) v1(86.61,81.53) v1(86.61,56.13) v1(86.61,51.05) v1(86.61,45.97) v1(86.61,40.89) v1(86.61,30.73) v1(86.61,5.33) v1(86.73,61.72) v1(86.75,18.85) v1(88.25,65.07) v1(89.15,190.75) v1(89.15,129.79) v1(89.15,124.71) v1(89.15,119.63) v1(89.15,114.55) v1(89.15,109.47) v1(89.15,104.39) v1(89.15,94.23) v1(89.15,58.67) v1(89.15,53.59) v1(89.15,43.43) v1(89.15,33.27) v1(89.15,29.69) v1(89.15,28.19) v1(89.09,20.19) v1(89.15,2.79) v1(89.19,12.27) v1(89.6,47.17) v1(90.06,65.05) v1(90.44,81.53) v1(90.54,146.69) v1(90.62,61.57) v1(91.69,183.13) v1(91.69,142.49) v1(91.69,132.33) v1(91.69,117.09) v1(91.69,112.01) v1(91.69,106.93) v1(91.69,96.77) v1(91.69,91.69) v1(91.69,61.21) v1(91.69,56.13) v1(91.69,51.05) v1(91.69,40.89) v1(91.69,30.73) v1(91.69,20.57) v1(91.73,18.39) v1(91.69,10.41) v1(91.69,5.33) v1(92.01,87.2) v1(92.42,14.4) v1(93.76,16.36) v1(93.84,58.72) v1(94.23,185.67) v1(94.23,134.87) v1(94.23,129.79) v1(94.23,119.63) v1(94.23,114.55) v1(94.23,109.47) v1(94.23,104.39) v1(94.23,99.31) v1(94.23,94.23) v1(94.23,89.15) v1(94.23,73.91) v1(94.23,63.75) v1(94.23,53.59) v1(94.23,43.43) v1(94.23,33.27) v1(94.23,29.69) v1(94.23,28.19) v1(94.23,23.11) v1(94.23,18.03) v1(94.23,12.95) v1(94.23,7.87) v1(94.23,2.79) v1(95.62,127.13) v1(96.77,193.29) v1(96.77,157.73) v1(96.77,147.57) v1(96.77,132.33) v1(96.77,112.01) v1(96.77,106.93) v1(96.77,96.77) v1(96.77,91.69) v1(96.77,86.61) v1(96.77,40.89) v1(96.77,35.81) v1(96.77,30.73) v1(96.77,25.65) v1(96.77,20.57) v1(96.77,15.49) v1(96.77,10.41) v1(98.55,65.15) v1(98.55,64.52) v1(99.18,152.02) v1(99.19,65.15) v1(99.19,64.52) v1(99.31,190.75) v1(99.31,185.67) v1(99.31,165.35) v1(99.31,155.19) v1(99.31,145.03) v1(99.31,134.87) v1(99.31,129.79) v1(99.31,104.39) v1(99.31,99.31) v1(99.31,94.23) v1(99.31,73.91) v1(99.31,63.75) v1(99.31,53.59) v1(99.31,43.43) v1(99.31,33.27) v1(99.31,29.69) v1(99.31,28.19) v1(99.31,23.11) v1(99.31,18.03) v1(99.31,12.95) v1(99.31,7.87) v1(99.99,2.84) v1(100.57,104.39) v1(101.21,163.58) v1(101.85,193.29) v1(101.85,188.21) v1(101.85,157.73) v1(101.85,142.49) v1(101.85,132.33) v1(101.85,122.17) v1(101.85,117.09) v1(101.85,96.77) v1(101.85,40.89) v1(101.85,35.81) v1(101.85,30.73) v1(101.85,25.65) v1(101.85,20.57) v1(101.85,15.49) v1(101.8,11.38) v1(101.83,10.03) v1(101.85,5.33) v1(101.97,126.87) v1(101.92,59.88) v1(101.92,59.31) v1(101.92,58.74) v1(102.15,56.01) v1(102.49,59.88) v1(102.49,59.31) v1(102.49,58.74) v1(102.6,46.91) v1(103.06,59.88) v1(103.06,59.31) v1(103.06,58.74) v1(103.21,2.84) v1(103.37,104.39) v1(103.49,116.08) v1(104.13,115.95) v1(104.39,139.95) v1(104.39,124.71) v1(104.39,119.63) v1(104.39,104.39) v1(104.39,53.59) v1(104.39,48.51) v1(104.39,43.43) v1(104.39,33.27) v1(104.39,29.69) v1(104.39,28.19) v1(104.39,23.11) v1(104.39,18.03) v1(104.39,12.95) v1(104.39,7.87) v1(106.88,11.38) v1(106.93,162.81) v1(106.93,147.57) v1(106.93,142.49) v1(106.93,127.25) v1(106.93,122.17) v1(106.93,117.09) v1(106.93,106.93) v1(106.93,101.85) v1(106.93,56.13) v1(106.93,45.97) v1(106.93,35.81) v1(106.93,30.73) v1(106.93,25.65) v1(106.93,20.57) v1(106.93,15.49) v1(106.91,10.03) v1(108.32,111.38) v1(108.83,147.57) v1(109.08,112.52) v1(109.47,190.75) v1(109.47,180.59) v1(109.47,145.03) v1(109.47,124.71) v1(109.47,119.63) v1(109.47,104.39) v1(109.47,48.51) v1(109.47,38.35) v1(109.47,33.27) v1(109.47,29.69) v1(109.47,28.19) v1(109.47,23.11) v1(109.47,18.03) v1(109.47,12.95) v1(109.47,7.87) v1(109.59,115.7) v1(110.05,63.78) v1(110.24,71.75) v1(110.24,71.12) v1(110.35,59.31) v1(110.87,71.75) v1(110.87,71.12) v1(110.99,101.85) v1(111.51,71.75) v1(111.51,71.12) v1(111.96,11.38) v1(112.01,193.29) v1(112.01,162.81) v1(112.01,127.25) v1(112.01,122.17) v1(112.01,117.09) v1(112.01,51.05) v1(112.01,40.89) v1(112.01,35.81) v1(112.01,30.73) v1(112.01,25.65) v1(112.01,20.57) v1(112.01,15.49) v1(111.99,10.03) v1(112.01,5.33) v1(113.02,115.95) v1(113.65,101.85) v1(113.78,115.95) v1(114.55,190.75) v1(114.55,180.59) v1(114.55,165.35) v1(114.55,145.03) v1(114.55,134.87) v1(114.55,63.75) v1(114.55,53.59) v1(114.55,43.43) v1(114.55,38.35) v1(114.55,33.27) v1(114.55,29.69) v1(114.55,28.19) v1(114.55,23.11) v1(114.55,18.03) v1(114.55,12.95) v1(114.55,7.87) v1(114.55,2.79) v1(114.92,147.7) v1(114.93,111.56) v1(115.18,114.17) v1(115.28,82.58) v1(115.43,101.47) v1(115.56,108.97) v1(115.89,64.49) v1(116.83,104.65) v1(116.83,103.89) v1(116.96,132.46) v1(116.96,102.23) v1(117.04,11.38) v1(117.07,10.03) v1(117.09,193.29) v1(117.09,172.97) v1(117.09,162.81) v1(117.09,147.57) v1(117.09,112.01) v1(117.09,56.13) v1(117.09,45.97) v1(117.09,40.89) v1(117.09,35.81) v1(117.09,30.73) v1(117.09,25.65) v1(117.09,20.57) v1(117.09,15.49) v1(117.09,5.33) v1(117.59,114.43) v1(118.07,82.63) v1(119.63,165.35) v1(119.63,134.87) v1(119.63,129.79) v1(119.63,89.15) v1(119.63,84.07) v1(119.63,58.67) v1(119.63,48.51) v1(119.63,43.43) v1(119.63,38.35) v1(119.63,33.27) v1(119.63,29.69) v1(119.63,28.19) v1(119.63,23.11) v1(119.63,18.03) v1(119.63,12.95) v1(119.63,7.87) v1(119.63,2.79) v1(120.77,108.84) v1(121.27,120.65) v1(121.4,188.85) v1(122.17,193.29) v1(122.17,172.97) v1(122.17,142.49) v1(122.17,132.33) v1(122.17,127.25) v1(122.17,117.09) v1(122.17,51.05) v1(122.17,45.97) v1(122.17,40.89) v1(122.17,35.81) v1(122.17,30.73) v1(122.17,25.65) v1(122.17,20.57) v1(122.17,15.49) v1(122.12,11.38) v1(122.15,10.03) v1(122.17,5.33) v1(122.66,83.73) v1(123.56,181.48) v1(124.07,147.83) v1(124.07,94.41) v1(124.71,190.75) v1(124.71,155.19) v1(124.71,145.03) v1(124.71,134.87) v1(124.71,63.75) v1(124.71,53.59) v1(124.71,48.51) v1(124.71,43.43) v1(124.71,38.35) v1(124.71,33.27) v1(124.71,29.69) v1(124.71,28.19) v1(124.71,23.11) v1(124.71,18.03) v1(124.71,12.95) v1(124.71,7.87) v1(124.71,2.79) v1(124.96,180.59) v1(126.06,11.35) v1(126.09,10.01) v1(126.89,62.79) v1(127.25,193.29) v1(127.25,172.97) v1(127.25,132.33) v1(127.25,122.17) v1(127.25,117.09) v1(127.25,56.13) v1(127.25,51.05) v1(127.25,45.97) v1(127.25,35.81) v1(127.25,30.73) v1(127.25,25.65) v1(127.25,16.13) v1(128.87,56.9) v1(129.02,180.59) v1(129.35,61.87) v1(129.4,190.75) v1(129.77,17.53) v1(129.79,165.35) v1(129.79,134.87) v1(129.79,129.79) v1(129.79,124.71) v1(129.79,114.55) v1(129.79,104.39) v1(129.79,94.23) v1(129.79,33.27) v1(129.79,29.69) v1(129.79,28.19) v1(130.59,63.6) v1(132.33,188.21) v1(132.33,183.13) v1(132.33,178.05) v1(132.33,172.97) v1(132.33,157.73) v1(132.33,147.57) v1(132.33,132.33) v1(132.33,122.17) v1(132.33,106.93) v1(132.33,51.05) v1(132.33,35.81) v1(132.33,16.13) v1(132.4,25.15) v1(132.58,193.29) v1(132.58,33.66) v1(132.55,29.79) v1(133.59,27.69) v1(133.86,30.1) v1(133.86,22.61) v1(134.1,124.71) v1(134.48,147.7) v1(134.48,140.34) v1(134.63,43.43) v1(134.62,25.27) v1(134.74,115.32) v1(134.74,114.43) v1(134.74,106.68) v1(134.87,190.75) v1(134.87,180.59) v1(134.87,145.03) v1(134.87,104.39) v1(134.87,63.75) v1(134.87,28.19) v1(134.85,17.53) v1(135.12,33.66) v1(135.13,31.8) v1(135.22,29.79) v1(135.57,61.72) v1(135.51,44.45) v1(135.51,43.44) v1(135.51,42.42) v1(136.52,44.45) v1(136.52,43.44) v1(136.52,42.42) v1(136.52,36.45) v1(136.51,35.69) v1(136.52,33.02) v1(137.41,193.29) v1(137.41,188.21) v1(137.41,183.13) v1(137.41,178.05) v1(137.41,172.97) v1(137.41,162.81) v1(137.41,157.73) v1(137.41,132.33) v1(137.41,122.17) v1(137.41,117.09) v1(137.41,101.85) v1(137.41,16.13) v1(137.54,44.45) v1(137.54,43.44) v1(137.54,42.42) v1(137.83,29.85) v1(137.86,28.24) v1(137.91,33.66) v1(138.19,95.94) v1(138.43,25.27) v1(139.19,30.23) v1(139.57,22.73) v1(139.95,190.75) v1(139.95,185.67) v1(139.95,180.59) v1(139.95,165.35) v1(139.95,145.03) v1(139.95,119.63) v1(139.95,114.55) v1(139.95,104.39) v1(139.93,17.53) v1(140.45,33.66) v1(140.46,31.8) v1(140.53,29.85) v1(140.96,99.82) v1(141.57,24.77) v1(141.85,39.5) v1(142.1,29.69) v1(142.18,27.74) v1(142.46,70.15) v1(142.41,16.1) v1(142.49,193.29) v1(142.49,188.21) v1(142.49,183.13) v1(142.49,172.97) v1(142.49,162.81) v1(142.49,157.73) v1(142.49,142.49) v1(142.49,137.41) v1(142.49,132.33) v1(142.49,127.25) v1(142.49,122.17) v1(142.49,117.09) v1(142.49,112.01) v1(142.49,91.69) v1(142.49,35.81) v1(142.49,30.73) v1(142.86,41.78) v1(143.24,39.75) v1(143.24,38.99) v1(143.24,38.23) v1(143.5,61.85) v1(143.5,41.15) v1(143.5,37.34) v1(143.88,102.49) v1(143.88,99.95) v1(144.13,40.51) v1(144.26,33.27) v1(144.39,39.75) v1(144.39,38.99) v1(144.39,38.23) v1(144.39,36.96) v1(144.82,95.94) v1(145.03,190.75) v1(145.03,185.67) v1(145.03,175.51) v1(145.03,160.27) v1(145.03,155.19) v1(145.03,119.63) v1(145.03,114.55) v1(145.03,29.69) v1(145.03,28.19) v1(145.01,17.53) v1(145.14,45.81) v1(145.15,39.75) v1(145.15,36.7) v1(145.1,32.35) v1(145.53,70.21) v1(145.86,32.35) v1(145.9,45.81) v1(145.91,39.75) v1(145.91,36.7) v1(145.99,61.8) v1(146.66,45.81) v1(146.67,39.75) v1(146.63,32.35) v1(146.96,11.35) v1(146.99,10.01) v1(147.43,45.81) v1(147.44,39.5) v1(147.39,32.35) v1(147.57,193.29) v1(147.57,188.21) v1(147.57,178.05) v1(147.57,172.97) v1(147.57,162.81) v1(147.57,157.73) v1(147.57,152.65) v1(147.57,132.33) v1(147.57,122.17) v1(147.57,56.13) v1(147.57,51.05) v1(147.57,30.73) v1(147.57,25.65) v1(147.57,20.57) v1(147.57,15.49) v1(147.66,71.25) v1(148.12,63.04) v1(148.2,39.5) v1(148.48,46.89) v1(148.43,40.97) v1(148.71,180.59) v1(149.09,190.63) v1(150.11,160.27) v1(150.11,155.19) v1(150.11,150.11) v1(150.11,109.47) v1(150.11,43.43) v1(150.11,38.35) v1(150.11,33.27) v1(150.11,29.69) v1(150.11,28.19) v1(150.11,23.11) v1(150.11,18.03) v1(150.11,12.95) v1(150.11,2.79) v1(150.2,61.8) v1(152.16,4.27) v1(152.65,193.29) v1(152.65,172.97) v1(152.65,162.81) v1(152.65,157.73) v1(152.65,152.65) v1(152.65,147.57) v1(152.65,112.01) v1(152.65,56.13) v1(152.65,51.05) v1(152.65,45.97) v1(152.65,40.89) v1(152.65,35.81) v1(152.65,30.73) v1(152.65,25.65) v1(152.65,15.49) v1(152.6,11.4) v1(152.63,10.06) v1(152.65,5.33) v1(153.07,61.93) v1(153.02,20.12) v1(154.78,96.29) v1(155.16,70.36) v1(155.19,190.75) v1(155.19,180.59) v1(155.19,160.27) v1(155.19,155.19) v1(155.19,150.11) v1(155.19,139.95) v1(155.19,134.87) v1(155.19,129.79) v1(155.19,124.71) v1(155.19,119.63) v1(155.19,114.55) v1(155.19,109.47) v1(155.19,89.15) v1(155.19,78.99) v1(155.19,63.75) v1(155.19,53.59) v1(155.19,48.51) v1(155.19,43.43) v1(155.19,38.35) v1(155.19,33.27) v1(155.19,29.69) v1(155.19,28.19) v1(155.19,23.11) v1(155.19,18.03) v1(155.19,12.95) v1(155.19,2.79) v1(156.83,186.18) v1(156.88,96.01) v1(157.14,71.88) v1(157.65,20.12) v1(157.73,193.29) v1(157.73,172.97) v1(157.73,162.81) v1(157.73,157.73) v1(157.73,152.65) v1(157.73,142.49) v1(157.73,137.41) v1(157.73,132.33) v1(157.73,127.25) v1(157.73,122.17) v1(157.73,117.09) v1(157.73,112.01) v1(157.73,91.69) v1(157.73,81.53) v1(157.73,51.05) v1(157.73,45.97) v1(157.73,40.89) v1(157.73,30.73) v1(157.73,25.65) v1(157.73,15.49) v1(157.78,11.38) v1(157.73,5.33) v1(157.81,10.03) v1(158.79,70.21) v1(158.89,95.45) v1(160.27,190.75) v1(160.27,180.59) v1(160.27,175.51) v1(160.27,160.27) v1(160.27,155.19) v1(160.27,145.03) v1(160.27,139.95) v1(160.27,134.87) v1(160.27,129.79) v1(160.27,124.71) v1(160.27,119.63) v1(160.27,114.55) v1(160.27,109.47) v1(160.27,89.15) v1(160.27,63.75) v1(160.27,48.51) v1(160.27,43.43) v1(160.27,33.27) v1(160.27,29.69) v1(160.27,28.19) v1(160.27,18.03) v1(160.27,12.95) v1(160.29,71.78) v1(162.52,70.54) v1(162.8,193.93) v1(162.81,178.05) v1(162.81,162.81) v1(162.81,157.73) v1(162.81,147.57) v1(162.81,142.49) v1(162.81,137.41) v1(162.81,132.33) v1(162.81,127.25) v1(162.81,122.17) v1(162.81,117.09) v1(162.81,112.01) v1(162.81,56.13) v1(162.81,45.97) v1(162.81,35.81) v1(162.81,20.57) v1(162.81,15.49) v1(162.84,11.4) v1(162.86,10.06) v1(162.81,5.33) v1(164.68,71.86) v1(164.83,100.08) v1(165.06,3.48) v1(165.35,190.75) v1(165.35,165.35) v1(165.35,160.27) v1(165.35,150.11) v1(165.35,145.03) v1(165.35,119.63) v1(165.35,114.55) v1(165.35,63.75) v1(165.35,53.59) v1(165.35,38.35) v1(165.35,29.69) v1(165.35,28.19) v1(165.35,18.03) v1(165.35,12.95) v1(166.61,61.8) v1(167.89,193.29) v1(167.89,188.21) v1(167.89,162.81) v1(167.89,152.65) v1(167.89,147.57) v1(167.89,142.49) v1(167.89,117.09) v1(167.89,106.93) v1(167.89,81.53) v1(167.89,71.37) v1(167.89,56.13) v1(167.89,51.05) v1(167.89,40.89) v1(167.89,30.73) v1(167.89,25.65) v1(167.89,20.57) v1(167.89,15.49) v1(167.89,5.33) v1(168.2,11.35) v1(168.22,10.01) v1(169.41,70.13) v1(170.43,190.75) v1(170.43,185.67) v1(170.43,170.43) v1(170.43,165.35) v1(170.43,155.19) v1(170.43,150.11) v1(170.43,145.03) v1(170.43,139.95) v1(170.43,119.63) v1(170.43,114.55) v1(170.43,109.47) v1(170.43,89.15) v1(170.43,53.59) v1(170.43,48.51) v1(170.43,43.43) v1(170.43,33.27) v1(170.43,29.69) v1(170.43,28.19) v1(170.43,18.03) v1(170.43,12.95) v1(170.43,2.79) v1(170.8,60.88) v1(171.29,71.96) v1(172.45,70.08) v1(172.97,193.29) v1(172.97,188.21) v1(172.97,183.13) v1(172.97,178.05) v1(172.97,172.97) v1(172.97,167.89) v1(172.97,157.73) v1(172.97,152.65) v1(172.97,147.57) v1(172.97,142.49) v1(172.97,137.41) v1(172.97,132.33) v1(172.96,130.68) v1(172.97,117.09) v1(172.97,91.69) v1(172.97,81.53) v1(172.97,61.21) v1(172.97,56.13) v1(172.97,51.05) v1(172.97,40.89) v1(172.97,35.81) v1(172.97,30.73) v1(172.97,25.65) v1(172.97,20.57) v1(172.97,15.49) v1(172.92,11.38) v1(172.95,10.03) v1(172.97,5.33) v1(173.34,129.54) v1(173.34,128.27) v1(173.34,127.51) v1(173.47,126.75) v1(173.6,131.19) v1(173.72,128.91) v1(174.23,126.49) v1(174.36,131.19) v1(174.36,71.86) v1(174.49,128.91) v1(174.99,126.49) v1(175.12,131.19) v1(175.51,190.75) v1(175.51,185.67) v1(175.51,180.59) v1(175.51,175.51) v1(175.51,170.43) v1(175.51,160.27) v1(175.51,155.19) v1(175.51,150.11) v1(175.51,145.03) v1(175.51,119.63) v1(175.51,114.55) v1(175.51,89.15) v1(175.51,63.75) v1(175.51,53.59) v1(175.51,48.51) v1(175.51,43.43) v1(175.51,33.27) v1(175.51,29.69) v1(175.51,28.19) v1(175.51,18.03) v1(175.51,12.95) v1(175.63,61.06) v1(175.68,57.53) v1(175.76,128.91) v1(175.76,126.49) v1(175.88,131.19) v1(176.52,128.91) v1(176.52,126.49) v1(176.65,131.19) v1(177.15,129.41) v1(177.15,128.52) v1(177.28,126.75) v1(177.25,30.73) v1(177.41,130.81) v1(177.66,130.05) v1(177.92,128.52) v1(178.05,193.29) v1(178.05,188.21) v1(178.05,183.13) v1(178.05,178.05) v1(178.05,172.97) v1(178.05,162.81) v1(178.05,157.73) v1(178.05,152.65) v1(178.05,147.57) v1(178.05,142.49) v1(178.05,137.41) v1(178.05,132.33) v1(178.04,126.75) v1(178.05,117.09) v1(178.05,91.69) v1(178.05,81.53) v1(178.05,71.37) v1(178.05,51.05) v1(178.05,40.89) v1(178.05,35.81) v1(178.05,25.65) v1(178.05,20.57) v1(178.05,15.49) v1(178.05,5.33) v1(178.1,11.4) v1(178.13,10.06) v1(178.3,123.32) v1(178.68,128.52) v1(178.68,123.95) v1(178.68,121.79) v1(178.8,126.62) v1(179.06,125.86) v1(179.44,128.52) v1(179.57,125.22) v1(179.57,121.41) v1(179.57,67.89) v1(179.9,33.27) v1(180.2,128.4) v1(180.59,190.75) v1(180.59,185.67) v1(180.59,180.59) v1(180.59,175.51) v1(180.59,165.35) v1(180.59,160.27) v1(180.59,155.19) v1(180.59,150.11) v1(180.59,145.03) v1(180.59,139.95) v1(180.59,134.87) v1(180.59,129.79) v1(180.59,114.55) v1(180.59,89.15) v1(180.59,68.83) v1(180.59,48.51) v1(180.59,43.43) v1(180.59,28.19) v1(180.59,23.11) v1(180.59,18.03) v1(180.59,12.95) v1(180.84,120.65) v1(180.84,119.13) v1(180.96,128.4) v1(181.09,125.22) v1(181.47,129.67) v1(181.47,128.91) v1(181.47,125.86) v1(181.85,126.49) v1(182.11,130.05) v1(182.23,101.09) v1(182.39,34.06) v1(182.44,30.78) v1(182.61,126.49) v1(182.87,130.05) v1(183.13,167.89) v1(183.13,162.81) v1(183.13,157.73) v1(183.13,152.65) v1(183.13,147.57) v1(183.13,142.49) v1(183.13,137.41) v1(183.13,132.33) v1(183.13,91.69) v1(183.13,81.53) v1(183.13,71.37) v1(183.13,25.65) v1(183.13,20.57) v1(183.13,15.49) v1(183.18,11.38) v1(183.21,10.03) v1(183.38,126.49) v1(183.35,124.69) v1(183.33,121.72) v1(183.63,130.05) v1(184.01,193.29) v1(184.14,126.49) v1(184.14,123.32) v1(184.39,130.05) v1(184.82,31.52) v1(184.9,126.49) v1(185,28.35) v1(185.03,23.04) v1(185.03,18.03) v1(185.15,130.05) v1(185.67,190.75) v1(185.67,185.67) v1(185.67,170.43) v1(185.67,165.35) v1(185.67,160.27) v1(185.67,155.19) v1(185.67,150.11) v1(185.67,145.03) v1(185.67,139.95) v1(185.67,134.87) v1(185.66,129.41) v1(185.67,124.71) v1(185.67,89.15) v1(185.67,78.99) v1(185.67,63.75) v1(185.67,12.95) v1(185.67,2.79) v1(186.17,71.78) v1(186.27,32.05) v1(186.42,129.41) v1(186.81,128.78) v1(186.81,128.02) v1(186.81,127.25) v1(186.81,126.49) v1(187.16,28.35) v1(187.11,23.04) v1(187.16,18.19) v1(187.24,64.82) v1(188.14,67.56) v1(188.21,193.29) v1(188.21,172.97) v1(188.21,167.89) v1(188.21,137.41) v1(188.21,132.33) v1(188.21,127.25) v1(188.21,122.17) v1(188.21,91.69) v1(188.21,35.81) v1(188.21,30.73) v1(188.21,25.65) v1(188.21,20.57) v1(188.43,14.3) v1(188.49,11.38) v1(188.52,10.03) v1(188.82,38.03) v1(189.33,37.53) v1(190.11,186.82) v1(190.36,70) v1(190.36,68.4) v1(190.75,190.75) v1(190.75,180.59) v1(190.75,175.51) v1(190.75,170.43) v1(190.75,165.35) v1(190.75,160.27) v1(190.75,129.79) v1(190.75,124.71) v1(190.72,60.4) v1(190.75,23.11) v1(190.75,18.03) v1(190.75,7.87) v1(190.75,2.79) v1(191.01,88.14) v1(191.01,84.58) v1(191.07,14.22) v1(191.3,11.35) v1(191.39,37.78) v1(191.77,88.14) v1(191.77,84.58) v1(191.94,86.36) v1(192.02,37.78) v1(192.14,71.83) v1(192.14,70.33) v1(192.66,37.78) v1(193.16,193.29) v1(193.29,172.97) v1(193.29,167.89) v1(193.29,162.81) v1(193.29,137.41) v1(193.29,127.25) v1(193.29,122.17) v1(193.29,101.85) v1(193.29,91.69) v1(193.29,76.45) v1(193.29,61.21) v1(193.43,59.61) v1(194.17,38.96) v1(195.83,175.51) v1(195.83,170.43) v1(195.83,165.35) v1(195.83,160.27) v1(195.83,139.95) v1(195.83,124.71) v1(195.83,109.47) v1(195.83,94.23) v1(195.83,48.51) v1(195.83,43.43) v1(195.83,33.27) v1(195.83,28.19) v1(195.83,2.79) v1(196.2,179.32) v1(196.46,190.75) v1(196.63,15.16) v1(197.14,68.15) v1(198.01,9.65) v1(198.37,193.29) v1(198.37,188.21) v1(198.37,172.97) v1(198.37,167.89) v1(198.37,132.33) v1(198.37,127.25) v1(198.37,122.17) v1(198.37,117.09) v1(198.37,91.69) v1(198.37,66.29) v1(198.37,40.89) v1(198.37,25.65) v1(198.41,16.31) v1(198.74,113.54) v1(198.78,33.08) v1(198.82,64.85) v1(199.61,68.12) v1(200.14,109.73) v1(200.52,72.8) v1(200.52,62.33) v1(200.91,190.75) v1(200.91,185.67) v1(200.91,165.35) v1(200.91,155.19) v1(200.91,139.95) v1(200.91,134.87) v1(200.91,124.71) v1(200.91,43.43) v1(200.91,38.35) v1(200.91,12.95) v1(200.91,7.87) v1(200.91,2.79) v1(201.1,36.77) v1(201.1,34.99) v1(201.1,33.21) v1(201.61,11.58) v1(201.92,64.87) v1(202.1,61.49) v1(202.5,36.77) v1(202.5,34.99) v1(202.5,33.21) v1(202.93,109.86) v1(203.45,193.29) v1(203.45,188.21) v1(203.45,183.13) v1(203.45,178.05) v1(203.45,172.97) v1(203.45,162.81) v1(203.45,157.73) v1(203.45,152.65) v1(203.45,147.57) v1(203.45,142.49) v1(203.45,137.41) v1(203.45,132.33) v1(203.45,127.25) v1(203.45,122.17) v1(203.45,117.09) v1(203.45,112.01) v1(203.45,96.77) v1(203.45,91.69) v1(203.45,40.89) v1(203.49,13.41) v1(203.77,36.77) v1(203.77,34.99) v1(203.77,33.21) v1(203.95,38.28) v1(204,76.5) v1(205.55,76.66) v1(205.99,185.67) v1(205.99,180.59) v1(205.99,175.51) v1(205.99,170.43) v1(205.99,155.19) v1(205.99,145.03) v1(205.99,139.95) v1(205.99,134.87) v1(205.99,12.95) v1(205.99,2.79) v1(206.25,13.65) v1(206.92,74.65) v1(207.4,76.61) v1(208.27,28.32) v1(208.53,172.97) v1(208.53,167.89) v1(208.53,132.33) v1(208.53,127.25) v1(208.53,122.17) v1(208.53,117.09) v1(208.53,112.01) v1(208.53,71.37) v1(208.9,188.21) v1(209.03,28.32) v1(209.04,13.65) v1(209.33,66.7) v1(209.79,28.32) v1(210.4,11.79) v1(210.55,28.32) v1(211.07,190.75) v1(211.07,175.51) v1(211.07,170.43) v1(211.07,165.35) v1(211.07,160.27) v1(211.07,155.19) v1(211.07,139.95) v1(211.07,84.07) v1(211.07,12.95) v1(211.07,2.79) v1(211.19,27.94) v1(211.19,27.18) v1(211.19,26.42) v1(211.7,15.24) v1(211.77,11.86) v1(212.21,14.73) v1(212.46,22.61) v1(212.51,35.76) v1(212.56,33.4) v1(212.59,73.02) v1(212.64,68) v1(212.59,32.46) v1(212.71,193.29) v1(212.71,14.22) v1(212.81,58.78) v1(213.61,188.21) v1(213.61,178.05) v1(213.61,172.97) v1(213.61,167.89) v1(213.61,162.81) v1(213.61,152.65) v1(213.6,147.07) v1(213.61,137.41) v1(213.61,122.17) v1(213.61,117.09) v1(213.61,112.01) v1(213.61,25.65) v1(213.99,34.35) v1(214.11,15.24) v1(214.2,11.35) v1(214.22,10.01) v1(214.41,76.25) v1(214.63,34.35) v1(214.62,20.7) v1(214.62,15.75) v1(215,23.88) v1(215.13,20.19) v1(215.13,16.26) v1(215.26,34.35) v1(215.38,69.98) v1(215.38,28.85) v1(215.63,19.69) v1(215.63,16.76) v1(215.66,15.65) v1(215.9,73.41) v1(215.9,72.9) v1(216.15,190.75) v1(216.15,185.67) v1(216.15,175.51) v1(216.15,165.35) v1(216.15,160.27) v1(216.15,84.2) v1(216.15,83.69) v1(216.15,63.75) v1(216.15,58.67) v1(216.14,19.18) v1(216.14,17.27) v1(216.15,12.95) v1(216.15,2.79) v1(216.4,180.59) v1(216.41,73.41) v1(216.4,22.61) v1(216.66,84.2) v1(216.66,83.69) v1(216.65,18.67) v1(216.65,17.78) v1(216.83,35.86) v1(217.26,33.58) v1(217.23,32) v1(217.79,21.08) v1(217.97,17.45) v1(218.03,11.35) v1(218.06,10.01) v1(218.57,78.74) v1(218.69,193.29) v1(218.69,142.49) v1(218.69,137.41) v1(218.69,127.25) v1(218.69,112.01) v1(218.69,61.21) v1(218.69,56.13) v1(218.69,40.89) v1(218.69,25.65) v1(219.07,78.74) v1(219.23,121.67) v1(219.29,30.43) v1(219.46,125.2) v1(219.48,117.35) v1(219.58,78.74) v1(219.7,44.96) v1(219.75,33.58) v1(220.71,114.05) v1(221.23,190.75) v1(221.23,180.59) v1(221.23,165.35) v1(221.23,160.27) v1(221.23,155.19) v1(221.23,145.03) v1(221.23,139.95) v1(221.23,134.87) v1(221.23,38.35) v1(221.23,28.19) v1(221.23,18.03) v1(221.23,13.02) v1(221.23,12.95) v1(221.23,12.26) v1(221.23,11.49) v1(221.23,2.79) v1(221.4,64.72) v1(221.4,32.46) v1(221.74,123.19) v1(221.74,122.43) v1(221.74,121.67) v1(221.74,120.9) v1(221.74,120.14) v1(222.25,73.41) v1(222.37,33.53) v1(222.29,9.86) v1(222.29,8.76) v1(222.29,7.8) v1(222.5,123.19) v1(222.5,122.43) v1(222.5,121.67) v1(222.5,120.9) v1(222.5,120.14) v1(222.76,73.41) v1(222.76,72.9) v1(223.27,123.19) v1(223.27,122.43) v1(223.27,121.67) v1(223.27,120.9) v1(223.27,120.14) v1(223.69,32.36) v1(223.77,193.29) v1(223.77,162.81) v1(223.77,157.73) v1(223.77,152.65) v1(223.77,147.57) v1(223.77,142.49) v1(223.77,137.41) v1(223.77,132.33) v1(223.77,35.81) v1(223.77,30.73) v1(223.77,25.65) v1(223.77,20.57) v1(223.75,17.4) v1(223.77,15.49) v1(223.77,5.33) v1(224.03,123.19) v1(224.03,122.43) v1(224.03,121.67) v1(224.03,120.9) v1(224.03,120.14) v1(224.27,180.59) v1(224.79,123.19) v1(224.79,122.43) v1(224.79,121.67) v1(224.79,120.9) v1(224.79,120.14) v1(225.06,70.08) v1(225.13,72.14) v1(225.55,65.15) v1(225.55,64.52) v1(225.62,32.41) v1(226.19,65.15) v1(226.19,64.52) v1(226.3,189.74) v1(226.31,160.27) v1(226.31,155.19) v1(226.31,145.03) v1(226.31,139.95) v1(226.31,134.87) v1(226.31,124.71) v1(226.31,63.75) v1(226.31,43.43) v1(226.35,37.52) v1(226.31,33.27) v1(226.31,23.11) v1(226.31,18.03) v1(226.31,12.95) v1(226.31,2.79) v1(227.08,101.22) v1(227.33,123.7) v1(227.33,122.92) v1(227.33,119.92) v1(227.33,119.13) v1(228.85,193.29) v1(228.85,188.21) v1(228.85,122.17) v1(228.85,117.09) v1(228.85,91.69) v1(228.85,66.29) v1(228.85,45.97) v1(228.85,25.65) v1(228.83,17.4) v1(228.85,15.49) v1(228.92,59.88) v1(228.92,59.31) v1(228.92,58.74) v1(229.1,113.92) v1(229.15,32.41) v1(229.49,59.88) v1(229.49,59.31) v1(229.49,58.74) v1(229.95,11.43) v1(229.95,10.06) v1(230.06,59.88) v1(230.06,59.31) v1(230.06,58.74) v1(230.98,31.14) v1(231,82.73) v1(231.31,7.26) v1(231.39,190.75) v1(231.39,170.43) v1(231.39,165.35) v1(231.39,155.19) v1(231.39,139.95) v1(231.39,124.71) v1(231.39,119.63) v1(231.39,28.19) v1(231.39,18.03) v1(231.39,12.95) v1(231.69,86.84) v1(232.63,49.91) v1(233.41,19.24) v1(233.93,193.29) v1(233.93,188.21) v1(233.93,172.97) v1(233.93,152.65) v1(233.93,147.57) v1(233.93,137.41) v1(233.93,127.25) v1(233.93,122.17) v1(233.93,117.09) v1(233.93,56.13) v1(233.93,30.73) v1(233.93,20.57) v1(233.93,15.49) v1(233.93,11.46) v1(233.93,10.08) v1(234.18,17.6) v1(234.44,21.27) v1(234.51,43.87) v1(234.56,32.38) v1(235.29,61.21) v1(235.93,28.93) v1(235.94,28.12) v1(235.93,27.3) v1(236.21,103) v1(236.47,190.75) v1(236.47,180.59) v1(236.47,160.27) v1(236.47,124.71) v1(236.47,119.63) v1(236.47,114.55) v1(236.47,23.11) v1(236.47,18.03) v1(236.47,12.95) v1(236.49,59.97) v1(237.24,71.25) v1(237.24,70.61) v1(237.25,64.54) v1(237.61,43.87) v1(237.87,71.25) v1(237.87,70.61) v1(237.96,49.71) v1(238.19,64.54) v1(238.47,55.88) v1(238.51,71.25) v1(238.51,70.61) v1(239.01,193.29) v1(239.01,183.13) v1(239.01,167.89) v1(239.01,142.49) v1(239.01,137.41) v1(239.01,132.33) v1(239.01,127.25) v1(239.01,122.17) v1(239.01,117.09) v1(239.01,112.01) v1(239.05,30.73) v1(239.01,25.65) v1(238.99,17.4) v1(239.01,15.49) v1(239.01,11.46) v1(239.01,10.08) v1(239.01,5.33) v1(240.22,31.09) v1(241.14,32.08) v1(241.55,185.67) v1(241.55,180.59) v1(241.55,160.27) v1(241.55,155.19) v1(241.55,139.95) v1(241.55,134.87) v1(241.55,124.71) v1(241.55,119.63) v1(241.55,114.55) v1(241.55,104.39) v1(241.55,28.19) v1(241.55,18.03) v1(241.55,12.95) v1(241.55,2.79) v1(242.69,21.77) v1(243.12,28.17) v1(244.07,17.4) v1(244.09,188.21) v1(244.09,183.13) v1(244.09,178.05) v1(244.09,162.81) v1(244.09,157.73) v1(244.09,152.65) v1(244.09,147.57) v1(244.09,142.49) v1(244.09,137.41) v1(244.09,132.33) v1(244.09,127.25) v1(244.09,122.17) v1(244.09,117.09) v1(244.09,86.61) v1(244.09,35.81) v1(244.09,30.73) v1(244.09,15.49) v1(244.09,11.46) v1(244.09,10.08) v1(244.09,5.33) v1(245.35,55.85) v1(245.78,22.76) v1(245.78,21.74) v1(246.63,180.59) v1(246.63,175.51) v1(246.63,139.95) v1(246.63,134.87) v1(246.63,119.63) v1(246.63,109.47) v1(246.63,104.39) v1(246.63,94.23) v1(246.63,89.15) v1(246.63,78.99) v1(246.63,38.35) v1(246.63,33.27) v1(246.63,28.19) v1(246.63,18.03) v1(246.63,12.95) v1(246.63,2.79) v1(249.17,183.13) v1(249.17,178.05) v1(249.17,172.97) v1(249.17,162.81) v1(249.17,157.73) v1(249.17,132.33) v1(249.17,127.25) v1(249.17,122.17) v1(249.17,112.01) v1(249.17,96.77) v1(249.17,91.69) v1(249.17,56.13) v1(249.17,35.81) v1(249.17,30.73) v1(249.17,15.49) v1(249.17,11.46) v1(249.17,10.08) v1(249.17,5.33) v1(249.49,25.55) v1(249.49,23.67) v1(251.71,180.59) v1(251.71,175.51) v1(251.71,160.27) v1(251.71,155.19) v1(251.71,139.95) v1(251.71,129.79) v1(251.71,114.55) v1(251.71,104.39) v1(251.71,94.23) v1(251.71,89.15) v1(251.71,48.51) v1(251.71,43.43) v1(251.71,38.35) v1(251.71,33.27) v1(251.71,28.19) v1(251.71,23.11) v1(251.71,18.03) v1(251.71,12.95) v1(251.71,7.87) v1(251.71,2.79) v1(253.06,11.35) v1(253.05,9.58) v1(253.61,27.79) v1(254.25,188.21) v1(254.25,183.13) v1(254.25,178.05) v1(254.25,167.89) v1(254.25,152.65) v1(254.25,137.41) v1(254.25,132.33) v1(254.25,127.25) v1(254.25,117.09) v1(254.25,112.01) v1(254.25,91.69) v1(254.25,51.05) v1(254.25,45.97) v1(254.25,35.81) v1(254.25,30.73) v1(254.25,25.65) v1(254.25,16.15) v1(255,118.74) v1(255.54,55.27) v1(256.79,190.75) v1(256.79,170.43) v1(256.79,160.27) v1(256.79,129.79) v1(256.79,114.55) v1(256.79,33.27) v1(256.84,17.45) v1(257.68,120.08) v1(257.68,119.32) v1(257.68,118.55) v1(257.8,71.73) v1(257.87,29.03) v1(257.87,27.81) v1(258.28,33.53) v1(258.44,120.08) v1(258.44,119.32) v1(258.44,118.55) v1(258.69,180.09) v1(259.21,120.08) v1(259.21,119.32) v1(259.21,118.55) v1(259.2,57.89) v1(259.33,188.21) v1(259.33,172.97) v1(259.33,162.81) v1(259.33,157.73) v1(259.33,152.65) v1(259.33,142.49) v1(259.33,137.41) v1(259.33,132.33) v1(259.33,127.25) v1(259.33,101.85) v1(259.33,51.05) v1(259.33,35.81) v1(259.33,16.15) v1(260.44,117.33) v1(260.86,30.1) v1(260.86,22.61) v1(261.2,87.99) v1(261.2,71.73) v1(261.48,180.09) v1(261.63,43.31) v1(261.62,25.27) v1(261.87,190.75) v1(261.87,175.51) v1(261.87,170.43) v1(261.87,160.27) v1(261.87,155.19) v1(261.87,150.11) v1(261.87,145.03) v1(261.87,139.95) v1(261.87,134.87) v1(261.87,129.79) v1(261.87,104.39) v1(261.92,17.45) v1(262.13,31.8) v1(262.24,29.03) v1(262.24,27.81) v1(262.29,60.2) v1(262.45,61.72) v1(262.51,44.45) v1(262.51,43.44) v1(262.51,42.42) v1(263.53,44.45) v1(263.53,43.44) v1(263.53,42.42) v1(263.53,36.45) v1(263.51,35.41) v1(263.53,33.02) v1(264.41,188.21) v1(264.41,183.13) v1(264.41,172.97) v1(264.41,162.81) v1(264.41,157.73) v1(264.41,152.65) v1(264.41,142.49) v1(264.41,137.41) v1(264.41,132.33) v1(264.41,127.25) v1(264.41,117.09) v1(264.41,112.01) v1(264.41,101.85) v1(264.41,16.15) v1(264.54,44.45) v1(264.54,43.44) v1(264.54,42.42) v1(264.66,60.17) v1(264.81,29.03) v1(264.81,27.81) v1(265.39,57.91) v1(265.43,25.27) v1(265.62,52.68) v1(266.19,30.23) v1(266.57,22.73) v1(266.95,190.75) v1(266.95,180.59) v1(266.95,175.51) v1(266.95,170.43) v1(266.95,165.35) v1(266.95,155.19) v1(266.95,134.87) v1(266.95,129.79) v1(266.95,119.63) v1(267,17.45) v1(267.46,31.8) v1(268.03,50.95) v1(268.82,33.55) v1(269.1,39.5) v1(269.1,29.08) v1(269.1,27.81) v1(269.48,16.13) v1(269.49,188.21) v1(269.49,172.97) v1(269.49,162.81) v1(269.49,137.41) v1(269.49,132.33) v1(269.49,127.25) v1(269.49,117.09) v1(269.49,112.01) v1(269.49,101.85) v1(269.49,76.45) v1(269.49,35.81) v1(269.49,30.73) v1(269.66,62.56) v1(269.74,40.39) v1(269.86,41.78) v1(270.24,39.75) v1(270.24,38.99) v1(270.24,38.23) v1(270.5,41.15) v1(270.63,37.34) v1(270.93,60.71) v1(271.13,40.51) v1(271.39,39.75) v1(271.39,38.99) v1(271.39,38.23) v1(271.39,36.96) v1(271.39,33.53) v1(271.74,51.61) v1(272.03,190.75) v1(272.03,185.67) v1(272.03,165.35) v1(272.03,160.27) v1(272.03,139.95) v1(272.03,129.79) v1(272.03,119.63) v1(272.03,114.55) v1(272.06,29.06) v1(272.03,27.79) v1(272.08,17.45) v1(272.14,45.81) v1(272.15,39.75) v1(272.15,36.7) v1(272.1,32.35) v1(272.25,62.33) v1(272.23,59.44) v1(272.4,180.34) v1(272.86,32.35) v1(272.9,45.81) v1(272.91,39.75) v1(272.91,36.7) v1(273.17,73.74) v1(273.55,58.04) v1(273.66,45.81) v1(273.67,39.75) v1(273.63,32.35) v1(273.93,177.42) v1(273.9,61.09) v1(274.19,101.85) v1(274.43,45.81) v1(274.44,39.5) v1(274.39,32.35) v1(274.57,193.29) v1(274.57,188.21) v1(274.57,183.13) v1(274.57,172.97) v1(274.57,162.81) v1(274.57,132.33) v1(274.57,127.25) v1(274.57,117.09) v1(274.57,112.01) v1(274.57,56.13) v1(274.57,51.05) v1(274.57,30.73) v1(274.57,25.65) v1(274.57,20.57) v1(274.57,15.49) v1(274.57,5.33) v1(274.68,11.46) v1(274.65,10.03) v1(275.2,39.5) v1(275.3,59.39) v1(275.35,41.3) v1(275.48,46.71) v1(276.34,71.7) v1(276.82,49.45) v1(276.98,57.96) v1(277.11,190.75) v1(277.11,185.67) v1(277.11,175.51) v1(277.11,170.43) v1(277.11,165.35) v1(277.11,139.95) v1(277.11,134.87) v1(277.11,119.63) v1(277.11,43.43) v1(277.11,38.35) v1(277.11,33.27) v1(277.14,29.06) v1(277.11,27.79) v1(277.11,23.11) v1(277.11,18.03) v1(277.11,12.95) v1(277.11,7.87) v1(277.11,2.79) v1(278.32,47.88) v1(279.03,55.83) v1(279.27,101.85) v1(279.65,193.29) v1(279.65,188.21) v1(279.65,183.13) v1(279.65,172.97) v1(279.65,162.81) v1(279.65,157.73) v1(279.65,152.65) v1(279.65,142.49) v1(279.65,137.41) v1(279.65,132.33) v1(279.65,127.25) v1(279.65,117.09) v1(279.65,112.01) v1(279.65,91.69) v1(279.65,76.45) v1(279.65,51.05) v1(279.65,45.97) v1(279.65,40.89) v1(279.65,35.81) v1(279.65,30.73) v1(279.65,25.65) v1(279.65,15.49) v1(279.65,5.33) v1(279.76,11.46) v1(279.73,10.03) v1(281.55,147.7) v1(282,61.52) v1(282.19,190.75) v1(282.19,185.67) v1(282.19,175.51) v1(282.19,170.43) v1(282.19,165.35) v1(282.19,160.27) v1(282.19,155.19) v1(282.19,145.03) v1(282.19,139.95) v1(282.19,134.87) v1(282.19,119.63) v1(282.19,89.15) v1(282.19,48.51) v1(282.19,43.43) v1(282.19,38.35) v1(282.19,33.27) v1(282.22,29.06) v1(282.19,27.79) v1(282.19,23.11) v1(282.19,18.03) v1(282.19,12.95) v1(282.19,7.87) v1(282.19,2.79) v1(284.06,71.75) v1(284.35,101.85) v1(284.73,193.29) v1(284.73,188.21) v1(284.73,183.13) v1(284.73,172.97) v1(284.73,167.89) v1(284.73,142.49) v1(284.73,137.41) v1(284.73,132.33) v1(284.73,127.25) v1(284.73,117.09) v1(284.73,112.01) v1(284.73,91.69) v1(284.73,86.61) v1(284.73,61.21) v1(284.73,45.97) v1(284.73,40.89) v1(284.73,35.81) v1(284.73,30.73) v1(284.73,25.65) v1(284.73,15.49) v1(284.73,5.33) v1(284.84,11.46) v1(284.81,10.03) v1(285.66,71.78) v1(286.37,179.96) v1(287.27,190.75) v1(287.27,185.67) v1(287.27,175.51) v1(287.27,170.43) v1(287.27,165.35) v1(287.27,160.27) v1(287.27,119.63) v1(287.27,89.15) v1(287.27,58.67) v1(287.27,43.43) v1(287.27,38.35) v1(287.27,33.27) v1(287.27,27.79) v1(287.27,18.03) v1(287.27,12.95) v1(287.27,7.87) v1(287.3,29.06) v1(288.15,71.45) v1(289.43,101.85) v1(289.81,193.29) v1(289.81,188.21) v1(289.81,172.97) v1(289.81,167.89) v1(289.81,162.81) v1(289.81,137.41) v1(289.81,132.33) v1(289.81,127.25) v1(289.81,117.09) v1(289.81,112.01) v1(289.81,91.69) v1(289.81,86.61) v1(289.81,61.21) v1(289.81,56.13) v1(289.81,45.97) v1(289.81,40.89) v1(289.81,35.81) v1(289.81,20.57) v1(289.81,15.49) v1(289.81,5.33) v1(289.92,11.46) v1(289.89,10.03) v1(291.83,71.48) v1(291.94,51.77) v1(292.35,190.75) v1(292.35,175.51) v1(292.35,170.43) v1(292.35,165.35) v1(292.35,160.27) v1(292.35,139.95) v1(292.35,119.63) v1(292.35,104.39) v1(292.35,89.15) v1(292.35,58.67) v1(292.35,53.59) v1(292.35,43.43) v1(292.35,38.35) v1(292.35,33.27) v1(292.38,29.06) v1(292.35,27.79) v1(292.35,18.03) v1(292.35,12.95) v1(292.35,7.87) v1(293.87,115.7) v1(294.89,193.29) v1(294.89,183.13) v1(294.89,172.97) v1(294.89,167.89) v1(294.89,112.01) v1(294.89,91.69) v1(294.89,61.21) v1(294.89,56.13) v1(294.89,51.69) v1(294.89,45.97) v1(294.89,40.89) v1(294.89,35.81) v1(294.89,30.73) v1(294.89,25.65) v1(294.89,20.57) v1(294.89,15.49) v1(294.97,10.03) v1(294.89,5.33) v1(295,11.46) v1(296.95,121.67) v1(297.19,125.2) v1(297.2,117.35) v1(297.33,57.81) v1(297.43,180.59) v1(297.43,170.43) v1(297.43,165.35) v1(297.43,160.27) v1(297.43,155.19) v1(297.43,139.95) v1(297.43,134.87) v1(297.43,53.59) v1(297.43,43.43) v1(297.43,38.35) v1(297.43,33.27) v1(297.46,29.06) v1(297.43,27.79) v1(297.43,18.03) v1(297.43,12.95) v1(297.43,7.87) v1(297.43,2.79) v1(299.47,123.19) v1(299.47,122.43) v1(299.47,121.67) v1(299.47,120.9) v1(299.47,120.14) v1(299.97,193.29) v1(299.97,183.13) v1(299.97,178.05) v1(299.97,167.89) v1(299.97,162.81) v1(299.97,157.73) v1(299.97,152.65) v1(299.97,147.57) v1(299.97,142.49) v1(299.97,137.41) v1(299.97,132.33) v1(299.97,56.13) v1(299.97,51.69) v1(299.97,45.97) v1(299.97,40.89) v1(299.97,35.81) v1(299.97,30.73) v1(299.97,25.65) v1(299.97,20.57) v1(299.97,15.49) v1(299.97,5.33) v1(300.08,11.46) v1(300.05,10.03) v1(300.23,123.19) v1(300.23,122.43) v1(300.23,121.67) v1(300.23,120.9) v1(300.23,120.14) v1(300.99,123.19) v1(300.99,122.43) v1(300.99,121.67) v1(300.99,120.9) v1(300.99,120.14) v1(301.75,123.19) v1(301.75,122.43) v1(301.75,121.67) v1(301.75,120.9) v1(301.75,120.14) v1(302.02,70.84) v1(302.41,57.81) v1(302.51,190.75) v1(302.51,185.67) v1(302.51,180.59) v1(302.51,175.51) v1(302.51,165.35) v1(302.51,160.27) v1(302.51,155.19) v1(302.51,145.03) v1(302.51,139.95) v1(302.51,134.87) v1(302.51,123.19) v1(302.51,122.43) v1(302.51,121.67) v1(302.51,120.9) v1(302.51,120.14) v1(302.51,94.23) v1(302.51,53.59) v1(302.51,43.43) v1(302.51,38.35) v1(302.51,33.27) v1(302.54,29.06) v1(302.51,27.79) v1(302.51,18.03) v1(302.51,12.95) v1(302.51,7.87) v1(302.88,147.57) v1(305.05,193.29) v1(305.05,188.21) v1(305.05,183.13) v1(305.05,178.05) v1(305.05,172.97) v1(305.05,167.89) v1(305.05,142.49) v1(305.05,137.41) v1(305.05,123.7) v1(305.05,122.92) v1(305.05,122.17) v1(305.05,119.92) v1(305.05,119.13) v1(305.05,117.09) v1(305.05,96.77) v1(305.05,81.53) v1(305.05,56.13) v1(305.05,51.69) v1(305.05,45.97) v1(305.05,40.89) v1(305.05,35.81) v1(305.05,30.73) v1(305.05,25.65) v1(305.05,20.57) v1(305.05,15.49) v1(305.05,5.33) v1(305.16,11.46) v1(305.13,10.03) v1(307.49,57.81) v1(307.59,185.67) v1(307.59,180.59) v1(307.59,175.51) v1(307.59,170.43) v1(307.59,165.35) v1(307.59,160.27) v1(307.59,119.63) v1(307.59,84.07) v1(307.59,78.99) v1(307.59,53.59) v1(307.59,43.43) v1(307.59,38.35) v1(307.59,33.27) v1(307.59,23.11) v1(307.59,18.03) v1(307.59,12.95) v1(307.59,7.87) v1(310.13,188.21) v1(310.13,183.13) v1(310.13,178.05) v1(310.13,172.97) v1(310.13,167.89) v1(310.13,162.81) v1(310.13,137.41) v1(310.13,127.25) v1(310.13,117.09) v1(310.13,112.01) v1(310.13,81.53) v1(310.13,56.13) v1(310.13,51.69) v1(310.13,45.97) v1(310.13,40.89) v1(310.13,35.81) v1(310.13,25.65) v1(310.13,20.57) v1(310.13,15.49) v1(310.24,11.46) v1(310.21,10.03) v1(310.4,70.82) v1(312.57,57.81) v1(312.67,190.75) v1(312.67,185.67) v1(312.67,180.59) v1(312.67,175.51) v1(312.67,170.43) v1(312.67,165.35) v1(312.67,160.27) v1(312.67,139.95) v1(312.67,124.71) v1(312.67,114.55) v1(312.67,84.07) v1(312.67,53.59) v1(312.67,43.43) v1(312.67,38.35) v1(312.67,28.19) v1(312.67,23.11) v1(312.67,18.03) v1(312.67,12.95) v1(312.67,7.87) v1(312.67,2.79) v1(313.09,68.38) v1(315.21,193.29) v1(315.21,188.21) v1(315.21,183.13) v1(315.21,178.05) v1(315.21,172.97) v1(315.21,167.89) v1(315.21,162.81) v1(315.21,132.33) v1(315.21,127.25) v1(315.21,122.17) v1(315.21,112.01) v1(315.21,101.85) v1(315.21,86.61) v1(315.21,56.13) v1(315.21,51.69) v1(315.21,45.97) v1(315.21,40.89) v1(315.21,30.73) v1(315.21,25.65) v1(315.21,20.57) v1(315.21,15.49) v1(315.21,5.33) v1(315.32,11.46) v1(315.29,10.03) v1(316.73,107.7) v1(317.54,71.53) v1(317.54,70.74) v1(317.51,69.95) v1(317.65,57.81) v1(317.75,190.75) v1(317.75,185.67) v1(317.75,180.59) v1(317.75,175.51) v1(317.75,170.43) v1(317.75,165.35) v1(317.75,155.19) v1(317.75,139.95) v1(317.75,134.87) v1(317.75,124.71) v1(317.75,119.63) v1(317.75,89.15) v1(317.75,73.91) v1(317.75,53.59) v1(317.75,43.43) v1(317.75,33.27) v1(317.75,28.19) v1(317.75,23.11) v1(317.75,18.03) v1(317.75,12.95) v1(317.78,11.68) v1(317.75,7.87) v1(318.33,71.53) v1(318.33,70.74) v1(318.33,69.93) v1(320.28,70.61) v1(320.28,66.85) v1(320.29,193.29) v1(320.29,188.21) v1(320.29,183.13) v1(320.29,178.05) v1(320.29,172.97) v1(320.29,167.89) v1(320.29,162.81) v1(320.29,157.73) v1(320.29,152.65) v1(320.29,147.57) v1(320.29,142.49) v1(320.29,137.41) v1(320.29,132.33) v1(320.29,127.25) v1(320.29,122.17) v1(320.29,117.09) v1(320.29,112.01) v1(320.29,106.93) v1(320.29,81.53) v1(320.29,56.13) v1(320.29,51.69) v1(320.29,45.97) v1(320.29,35.81) v1(320.29,30.73) v1(320.29,25.65) v1(320.29,20.57) v1(320.29,15.49) v1(320.29,10.41) v1(320.29,5.33) v1(321.83,71.81) v1(322.62,53.57) v1(322.83,190.75) v1(322.83,185.67) v1(322.83,180.59) v1(322.83,175.51) v1(322.83,170.43) v1(322.83,165.35) v1(322.83,160.27) v1(322.83,155.19) v1(322.83,145.03) v1(322.83,139.95) v1(322.83,134.87) v1(322.83,124.71) v1(322.83,119.63) v1(322.83,114.55) v1(322.83,104.39) v1(322.83,68.83) v1(322.83,38.35) v1(322.83,33.27) v1(322.83,28.19) v1(322.83,23.11) v1(322.83,18.03) v1(322.83,12.95) v1(322.86,11.68) v1(322.83,7.87) v1(322.83,2.79) v1(324.47,188.21) v1(325.37,193.29) v1(325.37,183.13) v1(325.37,178.05) v1(325.37,172.97) v1(325.37,167.89) v1(325.37,132.33) v1(325.37,127.25) v1(325.37,122.17) v1(325.37,117.09) v1(325.37,106.93) v1(325.37,91.69) v1(325.37,81.53) v1(325.37,71.37) v1(325.37,66.29) v1(325.37,40.89) v1(325.37,35.81) v1(325.37,30.73) v1(325.37,25.65) v1(325.37,20.57) v1(325.37,10.41) v1(325.37,5.33) v1(326.05,92.99) v1(326.05,64.92) v1(326.1,45.59) v1(327.39,185.67) v1(327.91,190.75) v1(327.91,180.59) v1(327.91,175.51) v1(327.91,170.43) v1(327.91,165.35) v1(327.91,160.27) v1(327.91,155.19) v1(327.91,139.95) v1(327.91,124.71) v1(327.91,119.63) v1(327.91,114.55) v1(327.91,104.39) v1(327.91,99.31) v1(327.91,68.83) v1(327.91,43.43) v1(327.91,38.35) v1(327.91,33.27) v1(327.91,28.19) v1(327.91,23.11) v1(327.91,12.95) v1(327.94,11.68) v1(327.91,2.79) v1(328.66,193.29) v1(330.45,182.75) v1(330.45,178.05) v1(330.45,172.97) v1(330.45,167.89) v1(330.45,162.81) v1(330.45,152.65) v1(330.45,147.57) v1(330.45,137.41) v1(330.45,127.25) v1(330.45,122.17) v1(330.45,117.09) v1(330.45,106.93) v1(330.45,91.69) v1(330.45,71.37) v1(330.45,66.29) v1(330.45,56.13) v1(330.44,45.54) v1(330.45,40.89) v1(330.45,35.81) v1(330.45,30.73) v1(330.45,25.65) v1(330.45,20.57) v1(330.45,15.49) v1(330.45,10.41) v1(330.45,5.33) v1(332.78,69.65) v1(332.99,190.75) v1(332.99,180.59) v1(332.99,175.51) v1(332.99,170.43) v1(332.99,165.35) v1(332.99,160.27) v1(332.99,139.95) v1(332.99,129.79) v1(332.99,124.71) v1(332.99,119.63) v1(332.99,114.55) v1(332.99,104.39) v1(332.99,99.31) v1(332.99,78.99) v1(332.99,53.59) v1(332.99,43.43) v1(332.99,38.35) v1(332.99,33.27) v1(332.99,23.11) v1(332.99,12.95) v1(332.99,2.79) v1(334.51,58.8) v1(334.89,189.1) v1(335.12,11.66) v1(335.47,52.04) v1(335.53,193.29) v1(335.53,182.75) v1(335.53,178.05) v1(335.53,172.97) v1(335.53,167.89) v1(335.53,132.33) v1(335.53,127.25) v1(335.53,122.17) v1(335.53,117.09) v1(335.53,112.01) v1(335.53,56.13) v1(335.53,30.73) v1(335.53,5.33) v1(335.66,190.75) v1(336.39,83.01) v1(336.42,190.75) v1(336.54,85.85) v1(337.19,190.75) v1(337.5,43.05) v1(337.68,52.02) v1(337.91,11.71) v1(338.07,180.59) v1(338.07,175.51) v1(338.07,170.43) v1(338.07,165.35) v1(338.07,160.27) v1(338.07,155.19) v1(338.07,150.11) v1(338.07,139.95) v1(338.07,134.87) v1(338.07,129.79) v1(338.07,124.71) v1(338.07,119.63) v1(338.07,114.55) v1(338.07,109.47) v1(338.07,104.39) v1(338.07,99.31) v1(338.07,94.23) v1(338.07,84.07) v1(338.07,78.99) v1(338.07,68.83) v1(338.07,58.67) v1(338.07,53.59) v1(338.07,33.27) v1(338.07,28.19) v1(338.07,12.95) v1(338.07,2.79) v1(339.13,43.54) v1(339.31,45.97) v1(340.51,51.66) v1(340.61,193.29) v1(340.61,182.75) v1(340.61,178.05) v1(340.61,172.97) v1(340.61,167.89) v1(340.61,162.81) v1(340.61,157.73) v1(340.61,152.65) v1(340.61,147.57) v1(340.61,142.49) v1(340.61,137.41) v1(340.61,132.33) v1(340.61,127.25) v1(340.61,122.17) v1(340.61,117.09) v1(340.61,112.01) v1(340.61,106.93) v1(340.61,101.85) v1(340.61,86.61) v1(340.61,66.29) v1(340.61,61.21) v1(340.61,56.13) v1(340.61,45.97) v1(340.61,40.89) v1(340.61,30.73) v1(340.61,5.33) v1(340.93,20.19) v1(343.15,190.75) v1(343.15,185.67) v1(343.15,175.51) v1(343.15,170.43) v1(343.15,165.35) v1(343.15,160.27) v1(343.15,155.19) v1(343.15,150.11) v1(343.15,145.03) v1(343.15,139.95) v1(343.15,134.87) v1(343.15,129.79) v1(343.15,124.71) v1(343.15,119.63) v1(343.15,114.55) v1(343.15,109.47) v1(343.15,104.39) v1(343.15,99.31) v1(343.15,84.07) v1(343.15,78.99) v1(343.15,68.83) v1(343.15,53.59) v1(343.15,43.43) v1(343.15,38.35) v1(343.15,33.27) v1(343.15,28.19) v1(343.15,23.11) v1(343.15,2.79) v1(343.79,179.45) v1(343.79,178.56) v1(344.93,179.45) v1(344.93,178.56) v1(345.56,5.08) v1(345.59,51.66) v1(345.69,193.29) v1(345.69,172.97) v1(345.69,167.89) v1(345.69,162.81) v1(345.69,157.73) v1(345.69,152.65) v1(345.69,147.57) v1(345.69,142.49) v1(345.69,137.41) v1(345.69,132.33) v1(345.69,127.25) v1(345.69,122.17) v1(345.69,117.09) v1(345.69,112.01) v1(345.69,106.93) v1(345.69,101.85) v1(345.69,91.69) v1(345.69,86.61) v1(345.69,56.13) v1(345.69,45.97) v1(345.69,40.89) v1(345.73,36.53) v1(345.69,30.73) v1(345.94,20.24) v1(346.07,179.45) v1(346.07,178.56) v1(347.22,179.45) v1(347.22,178.56) v1(348.23,175.51) v1(348.23,170.43) v1(348.23,165.35) v1(348.23,160.27) v1(348.23,155.19) v1(348.23,150.11) v1(348.23,145.03) v1(348.23,139.95) v1(348.23,134.87) v1(348.23,129.79) v1(348.23,124.71) v1(348.23,119.63) v1(348.23,114.55) v1(348.23,109.47) v1(348.23,104.39) v1(348.23,94.23) v1(348.23,84.07) v1(348.23,78.99) v1(348.23,68.83) v1(348.23,53.59) v1(348.23,33.27) v1(348.23,23.11) v1(348.23,18.03) v1(348.23,2.79) v1(349.06,13.06) v1(349.11,10.62) v1(350.27,179.71) v1(350.77,193.29) v1(350.77,178.05) v1(350.77,172.97) v1(350.77,167.89) v1(350.77,162.81) v1(350.77,157.73) v1(350.77,152.65) v1(350.77,147.57) v1(350.77,142.49) v1(350.77,137.41) v1(350.77,132.33) v1(350.77,127.25) v1(350.77,122.17) v1(350.77,117.09) v1(350.77,112.01) v1(350.77,106.93) v1(350.77,91.69) v1(350.77,86.61) v1(350.77,45.97) v1(350.77,30.73) v1(350.77,20.57) v1(350.77,5.33) v1(351.3,10.85) v1(351.41,179.71) v1(352.55,179.71) v1(352.95,51.77) v1(353.31,175.51) v1(353.31,170.43) v1(353.31,165.35) v1(353.31,160.27) v1(353.31,155.19) v1(353.31,150.11) v1(353.31,145.03) v1(353.31,139.95) v1(353.31,134.87) v1(353.31,129.79) v1(353.31,124.71) v1(353.31,119.63) v1(353.31,114.55) v1(353.31,109.47) v1(353.31,99.31) v1(353.31,94.23) v1(353.31,84.07) v1(353.31,78.99) v1(353.31,68.83) v1(353.31,43.43) v1(353.31,33.27) v1(353.31,28.19) v1(353.31,2.79) v1(353.69,179.71) v1(353.94,12.95) v1(354.7,11.66) v1(355.38,15.75) v1(355.85,193.29) v1(355.85,178.05) v1(355.85,172.97) v1(355.85,167.89) v1(355.85,162.81) v1(355.85,157.73) v1(355.85,152.65) v1(355.85,147.57) v1(355.85,142.49) v1(355.85,137.41) v1(355.85,132.33) v1(355.85,127.25) v1(355.85,122.17) v1(355.85,117.09) v1(355.85,112.01) v1(355.85,101.85) v1(355.85,91.69) v1(355.85,86.61) v1(355.85,76.45) v1(355.85,56.13) v1(355.85,40.89) v1(355.85,30.73) v1(355.85,20.57) v1(355.85,10.41) v1(355.85,5.33) v1(356.24,180.72) v1(356.65,51.92) v1(357.38,180.72) v1(358.39,175.51) v1(358.39,170.43) v1(358.39,165.35) v1(358.39,160.27) v1(358.39,155.19) v1(358.39,150.11) v1(358.39,145.03) v1(358.39,139.95) v1(358.39,134.87) v1(358.39,129.79) v1(358.39,124.71) v1(358.39,119.63) v1(358.39,114.55) v1(358.39,104.39) v1(358.39,99.31) v1(358.39,94.23) v1(358.39,84.07) v1(358.39,78.99) v1(358.39,73.91) v1(358.39,58.67) v1(358.39,53.59) v1(358.39,38.35) v1(358.39,33.27) v1(358.39,28.19) v1(358.39,23.11) v1(358.39,18.03) v1(358.39,12.95) v1(358.44,11.63) v1(358.39,7.87) v1(358.52,180.72) v1(358.89,50.09) v1(360.93,193.29) v1(360.93,183.13) v1(360.93,178.05) v1(360.93,172.97) v1(360.93,167.89) v1(360.93,162.81) v1(360.93,157.73) v1(360.93,152.65) v1(360.93,147.57) v1(360.93,142.49) v1(360.93,137.41) v1(360.93,132.33) v1(360.93,127.25) v1(360.93,122.17) v1(360.93,117.09) v1(360.93,106.93) v1(360.93,101.85) v1(360.93,86.61) v1(360.93,76.45) v1(360.93,66.29) v1(360.93,61.21) v1(360.93,56.13) v1(360.93,51.05) v1(360.93,35.81) v1(360.93,30.73) v1(360.93,25.65) v1(360.93,20.57) v1(360.93,15.49) v1(360.93,10.41) v1(361.81,84.18) v1(361.86,46.76) v1(363.47,185.67) v1(363.47,175.51) v1(363.47,170.43) v1(363.47,165.35) v1(363.47,160.27) v1(363.47,155.19) v1(363.47,150.11) v1(363.47,145.03) v1(363.47,139.95) v1(363.47,134.87) v1(363.47,129.79) v1(363.47,124.71) v1(363.47,119.63) v1(363.47,109.47) v1(363.47,104.39) v1(363.47,99.31) v1(363.47,94.23) v1(363.47,89.15) v1(363.47,33.27) v1(363.47,28.19) v1(363.47,23.11) v1(363.47,18.03) v1(363.47,12.95) v1(363.47,7.87) v1(363.47,2.79) v1(363.52,11.63) v1(364.3,36.93) v1(365.07,73.94) v1(365.07,68.86) v1(365.07,63.78) v1(365.07,58.7) v1(365.09,61.26) v1(365.34,86.08) v1(365.32,76.53) v1(365.42,71.4) v1(365.47,66.27) v1(365.72,56.13) v1(366.01,193.29) v1(366.01,178.05) v1(366.01,172.97) v1(366.01,167.89) v1(366.01,162.81) v1(366.01,157.73) v1(366.01,152.65) v1(366.01,147.57) v1(366.01,142.49) v1(366.01,137.41) v1(366.01,132.33) v1(366.01,127.25) v1(366.01,122.17) v1(366.01,112.01) v1(366.01,106.93) v1(366.01,101.85) v1(366.01,30.73) v1(366.01,25.65) v1(366.01,20.57) v1(366.01,15.49) v1(366.01,10.41) v1(366.01,5.33) v1(368.16,12.98) v1(368.21,11.66) v1(368.55,185.67) v1(368.54,184.79) v1(368.55,175.51) v1(368.55,170.43) v1(368.55,165.35) v1(368.55,160.27) v1(368.55,155.19) v1(368.55,150.11) v1(368.55,145.03) v1(368.55,139.95) v1(368.55,134.87) v1(368.55,129.79) v1(368.55,124.71) v1(368.55,119.63) v1(368.55,114.55) v1(368.55,109.47) v1(368.55,104.39) v1(368.55,99.31) v1(368.55,94.23) v1(368.52,84.1) v1(368.55,68.83) v1(368.55,63.75) v1(368.55,58.67) v1(368.55,43.43) v1(368.55,38.35) v1(368.55,33.27) v1(368.55,28.19) v1(368.55,23.11) v1(368.55,18.03) v1(368.55,7.87) v1(368.8,190.5) v1(369.44,186.56) v1(370.59,186.56) v1(370.62,15.37) v1(371.09,193.29) v1(371.09,188.21) v1(371.09,178.05) v1(371.09,162.81) v1(371.09,157.73) v1(371.09,152.65) v1(371.09,147.57) v1(371.09,142.49) v1(371.09,137.41) v1(371.09,132.33) v1(371.09,127.25) v1(371.09,122.17) v1(371.09,117.09) v1(371.09,112.01) v1(371.09,106.93) v1(371.09,101.85) v1(371.09,91.69) v1(371.09,86.61) v1(371.09,76.45) v1(371.09,61.21) v1(371.09,56.13) v1(371.09,40.89) v1(371.09,30.73) v1(371.09,25.65) v1(371.09,20.57) v1(371.09,10.41) v1(371.44,14.33) v1(371.73,186.56) v1(372.3,63.7) v1(372.81,58.65) v1(373.13,186.44) v1(373.57,72.26) v1(373.63,190.75) v1(373.63,175.51) v1(373.63,170.43) v1(373.63,165.35) v1(373.63,160.27) v1(373.63,155.19) v1(373.63,150.11) v1(373.63,145.03) v1(373.63,139.95) v1(373.63,134.87) v1(373.63,129.79) v1(373.63,124.71) v1(373.63,119.63) v1(373.63,114.55) v1(373.63,109.47) v1(373.63,104.39) v1(373.63,99.31) v1(373.63,94.23) v1(373.63,89.15) v1(373.63,84.07) v1(373.63,48.51) v1(373.63,38.35) v1(373.63,33.27) v1(373.63,28.19) v1(373.63,23.11) v1(373.63,18.03) v1(373.63,12.95) v1(373.88,16.69) v1(373.89,186.44) v1(373.93,59.99) v1(374.64,185.42) v1(375.3,62.31) v1(376.17,193.29) v1(376.17,188.21) v1(376.17,183.13) v1(376.17,178.05) v1(376.17,172.97) v1(376.17,167.89) v1(376.17,162.81) v1(376.17,157.73) v1(376.17,152.65) v1(376.17,147.57) v1(376.17,142.49) v1(376.17,137.41) v1(376.17,132.33) v1(376.17,127.25) v1(376.17,122.17) v1(376.17,117.09) v1(376.17,112.01) v1(376.17,106.93) v1(376.17,101.85) v1(376.17,91.69) v1(376.17,86.61) v1(376.17,81.53) v1(376.11,69.72) v1(376.17,51.05) v1(376.17,45.97) v1(376.17,35.81) v1(376.17,25.65) v1(376.17,20.57) v1(376.17,10.41) v1(376.17,5.33) v1(377.1,65.76) v1(377.25,58.17) v1(377.2,56.87) v1(377.76,16.69) v1(377.99,67.06) v1(378.09,59.44) v1(378.42,18.01) v1(378.65,88.9) v1(378.71,190.75) v1(378.71,185.67) v1(378.71,180.59) v1(378.71,175.51) v1(378.71,170.43) v1(378.71,165.35) v1(378.71,160.27) v1(378.71,155.19) v1(378.71,150.11) v1(378.71,145.03) v1(378.71,139.95) v1(378.71,134.87) v1(378.71,129.79) v1(378.71,124.71) v1(378.71,119.63) v1(378.71,114.55) v1(378.71,109.47) v1(378.71,104.39) v1(378.71,99.31) v1(378.71,94.23) v1(378.71,84.07) v1(378.71,78.99) v1(378.71,53.59) v1(378.71,48.51) v1(378.71,43.43) v1(378.71,23.11) v1(378.71,12.95) v1(378.71,2.79) v1(379.36,60.71) v1(379.87,18.03) v1(379.97,20.24) v1(380.35,16.69) v1(380.4,69.85) v1(380.61,61.98) v1(381.25,193.29) v1(381.25,188.21) v1(381.25,183.13) v1(381.25,178.05) v1(381.25,172.97) v1(381.25,167.89) v1(381.25,162.81) v1(381.25,157.73) v1(381.25,152.65) v1(381.25,147.57) v1(381.25,142.49) v1(381.25,137.41) v1(381.25,132.33) v1(381.25,127.25) v1(381.25,122.17) v1(381.25,117.09) v1(381.25,112.01) v1(381.25,106.93) v1(381.25,101.85) v1(381.25,91.69) v1(381.25,81.53) v1(381.25,51.05) v1(381.25,45.97) v1(381.25,40.89) v1(381.25,30.73) v1(381.25,5.33) v1(381.45,19.69) v1(381.8,63.22) v1(382.77,55.68) v1(383.25,56.9) v1(383.68,59.44) v1(383.79,190.75) v1(383.79,185.67) v1(383.79,180.59) v1(383.79,175.51) v1(383.79,170.43) v1(383.79,165.35) v1(383.79,160.27) v1(383.79,155.19) v1(383.79,150.11) v1(383.79,145.03) v1(383.79,139.95) v1(383.79,134.87) v1(383.79,129.79) v1(383.79,124.71) v1(383.79,119.63) v1(383.79,114.55) v1(383.79,109.47) v1(383.79,104.39) v1(383.79,99.31) v1(383.79,94.23) v1(383.79,53.59) v1(383.79,48.51) v1(383.79,43.43) v1(383.79,38.35) v1(383.79,12.95) v1(383.79,2.79) v1(383.91,69.8) v1(384.24,18.03) v1(384.47,65.76) v1(384.49,61.95) v1(385.36,16.74) v1(385.74,67.03) v1(386.33,193.29) v1(386.33,188.21) v1(386.33,183.13) v1(386.33,178.05) v1(386.33,172.97) v1(386.33,167.89) v1(386.33,162.81) v1(386.33,157.73) v1(386.33,152.65) v1(386.33,147.57) v1(386.33,142.49) v1(386.33,132.33) v1(386.33,127.25) v1(386.33,122.17) v1(386.33,117.09) v1(386.33,112.01) v1(386.33,106.93) v1(386.33,101.85) v1(386.33,96.77) v1(386.33,91.69) v1(386.33,51.05) v1(386.33,45.97) v1(386.33,40.89) v1(386.33,35.81) v1(386.33,30.73) v1(386.33,20.57) v1(386.33,15.49) v1(386.33,10.41) v1(386.33,5.33) v1(387.74,74.75) v1(388.15,63.2) v1(388.2,60.68) v1(388.25,58.14) v1(388.28,55.7) v1(388.35,117.6) v1(388.61,140.08) v1(388.87,190.75) v1(388.87,185.67) v1(388.87,175.51) v1(388.87,170.43) v1(388.87,165.35) v1(388.87,155.19) v1(388.87,150.11) v1(388.87,145.03) v1(388.87,134.87) v1(388.87,129.79) v1(388.87,124.71) v1(388.87,119.63) v1(388.87,109.47) v1(388.87,104.39) v1(388.87,99.31) v1(388.87,94.23) v1(388.87,78.99) v1(388.87,53.59) v1(388.87,48.51) v1(388.87,43.43) v1(388.87,38.35) v1(388.87,33.27) v1(388.87,28.19) v1(388.87,23.11) v1(388.87,18.03) v1(388.87,2.79) v1(389.37,68.28) v1(389.67,74.7) v1(390.28,16.76) v1(391.25,61.93) v1(391.35,59.41) v1(391.41,193.29) v1(391.41,188.21) v1(391.41,178.05) v1(391.41,167.89) v1(391.41,157.73) v1(391.41,147.57) v1(391.41,142.49) v1(391.41,132.33) v1(391.41,127.25) v1(391.41,122.17) v1(391.41,112.01) v1(391.41,101.85) v1(391.41,96.77) v1(391.41,91.69) v1(391.41,81.53) v1(391.41,71.37) v1(391.45,56.9) v1(391.41,51.05) v1(391.41,45.97) v1(391.41,40.89) v1(391.41,35.81) v1(391.41,30.73) v1(391.41,25.65) v1(391.41,20.57) v1(391.41,15.49) v1(391.41,5.33) v1(391.53,185.04) v1(391.53,151.89) v1(391.66,164.72) v1(392.29,75.51) v1(392.42,109.47) v1(392.49,68.33) v1(392.75,65.76) v1(392.82,16.28) v1(393,67.06) v1(393.76,17.27) v1(393.95,190.75) v1(393.95,185.67) v1(393.95,170.43) v1(393.95,165.35) v1(393.95,155.19) v1(393.95,150.11) v1(393.95,145.03) v1(393.95,139.95) v1(393.95,124.71) v1(393.95,119.63) v1(393.95,109.47) v1(393.95,104.39) v1(393.95,99.31) v1(393.95,94.23) v1(393.95,89.15) v1(393.95,78.99) v1(393.95,53.59) v1(393.95,48.51) v1(393.95,43.43) v1(393.95,38.35) v1(393.95,33.27) v1(393.95,28.19) v1(393.95,2.79) v1(394.25,63.2) v1(394.35,60.68) v1(394.35,58.19) v1(394.4,75.36) v1(394.45,55.17) v1(396.49,193.29) v1(396.49,188.21) v1(396.49,183.13) v1(396.49,167.89) v1(396.49,162.81) v1(396.49,147.57) v1(396.49,142.49) v1(396.49,127.25) v1(396.49,122.17) v1(396.49,117.09) v1(396.49,101.85) v1(396.49,96.77) v1(396.49,91.69) v1(396.49,86.61) v1(396.49,40.89) v1(396.49,35.81) v1(396.49,30.73) v1(396.49,20.57) v1(396.49,15.49) v1(396.49,10.41) v1(396.49,5.33) v1(398.13,114.55) v1(398.39,133.6) v1(398.41,68.91) v1(398.46,65.33) v1(398.46,61.67) v1(398.54,75.13) v1(398.64,67.28) v1(398.84,174.56) v1(398.84,173.99) v1(398.84,173.42) v1(398.84,154.11) v1(398.84,153.54) v1(398.84,152.97) v1(398.84,131.38) v1(398.84,130.81) v1(398.84,130.24) v1(398.84,108.52) v1(398.84,107.95) v1(398.84,107.38) v1(399.03,190.75) v1(399.03,185.67) v1(399.03,170.43) v1(399.03,165.35) v1(399.03,160.27) v1(399.03,155.19) v1(399.03,150.11) v1(399.03,145.03) v1(399.03,139.95) v1(399.02,129.16) v1(399.03,124.71) v1(399.03,119.63) v1(399.03,109.47) v1(399.03,104.39) v1(399.03,99.31) v1(399.03,94.23) v1(399.03,89.15) v1(399.03,84.07) v1(399.03,78.99) v1(399.03,58.67) v1(399.03,53.59) v1(399.03,48.51) v1(399.03,43.43) v1(399.03,38.35) v1(399.03,33.27) v1(399.03,28.19) v1(399.03,23.11) v1(399.03,18.03) v1(399.03,12.95) v1(399.03,7.87) v1(399.03,2.79) v1(399.12,64.19) v1(399.42,174.56) v1(399.42,173.99) v1(399.42,173.42) v1(399.42,154.11) v1(399.42,153.54) v1(399.42,152.97) v1(399.42,131.38) v1(399.42,130.81) v1(399.42,130.24) v1(399.42,108.52) v1(399.42,107.95) v1(399.42,107.38) v1(399.66,61.11) v1(399.99,174.56) v1(399.99,173.99) v1(399.99,173.42) v1(399.99,154.11) v1(399.99,153.54) v1(399.99,152.97) v1(399.99,131.38) v1(399.99,130.81) v1(399.99,130.24) v1(399.99,108.52) v1(399.99,107.95) v1(399.99,107.38) v1(400.72,64.01) v1(400.7,5.26) v1(401.16,66.22) v1(401.57,193.29) v1(401.57,188.21) v1(401.57,183.13) v1(401.57,81.53) v1(401.57,61.21) v1(401.57,56.13) v1(401.57,51.05) v1(401.57,45.97) v1(401.57,40.89) v1(401.57,35.81) v1(401.57,30.73) v1(401.57,25.65) v1(401.57,10.41) v1(402.32,63.73) v1(402.72,179.83) v1(402.72,179.2) v1(402.72,159.39) v1(402.72,158.75) v1(402.72,136.65) v1(402.72,136.02) v1(402.72,113.79) v1(402.72,113.16) v1(402.81,75.11) v1(403.35,179.83) v1(403.35,179.2) v1(403.35,159.39) v1(403.35,158.75) v1(403.35,136.65) v1(403.35,136.02) v1(403.35,113.79) v1(403.35,113.16) v1(403.31,66.6) v1(404.11,190.75) v1(404.11,185.67) v1(404.11,180.59) v1(404.11,165.35) v1(404.11,160.27) v1(404.11,145.03) v1(404.11,139.95) v1(404.11,124.71) v1(404.11,119.63) v1(404.11,114.55) v1(404.11,99.31) v1(404.11,94.23) v1(404.11,89.15) v1(404.11,84.07) v1(404.11,78.99) v1(404.11,63.75) v1(404.11,58.67) v1(404.11,53.59) v1(404.11,48.51) v1(404.11,43.43) v1(404.11,38.35) v1(404.11,33.27) v1(404.11,12.95) v1(404.11,2.79) v1(404.36,24.38) v1(404.66,66.22) v1(404.99,135) v1(406.65,193.29) v1(406.65,188.21) v1(406.65,183.13) v1(406.65,178.05) v1(406.65,167.89) v1(406.65,162.81) v1(406.65,157.73) v1(406.65,147.57) v1(406.65,142.49) v1(406.65,137.41) v1(406.65,122.17) v1(406.65,117.09) v1(406.65,112.01) v1(406.65,101.85) v1(406.65,96.77) v1(406.65,91.69) v1(406.65,86.61) v1(406.65,81.53) v1(406.65,61.21) v1(406.65,56.13) v1(406.65,51.05) v1(406.65,45.97) v1(406.65,40.89) v1(406.65,35.81) v1(406.65,30.73) v1(406.65,25.65) v1(406.65,15.49) v1(406.65,10.41) v1(406.65,5.33) v1(407.1,75.18) v1(407.4,66.93) v1(409.19,185.67) v1(409.19,180.59) v1(409.19,175.51) v1(409.19,170.43) v1(409.19,165.35) v1(409.19,160.27) v1(409.19,155.19) v1(409.19,150.11) v1(409.19,145.03) v1(409.19,139.95) v1(409.19,134.87) v1(409.19,129.79) v1(409.19,124.71) v1(409.19,119.63) v1(409.19,114.55) v1(409.19,109.47) v1(409.19,104.39) v1(409.19,99.31) v1(409.19,89.15) v1(409.19,84.07) v1(409.19,78.99) v1(409.19,68.83) v1(409.19,63.75) v1(409.19,58.67) v1(409.19,53.59) v1(409.19,48.51) v1(409.19,43.43) v1(409.19,38.35) v1(409.19,33.27) v1(409.19,28.19) v1(409.19,23.11) v1(409.19,18.03) v1(409.19,12.95) v1(409.19,7.87) v1(409.19,2.79) v1(411.73,188.21) v1(411.73,183.13) v1(411.73,178.05) v1(411.73,172.97) v1(411.73,167.89) v1(411.73,162.81) v1(411.73,157.73) v1(411.73,152.65) v1(411.73,147.57) v1(411.73,142.49) v1(411.73,137.41) v1(411.73,132.33) v1(411.73,127.25) v1(411.73,122.17) v1(411.73,117.09) v1(411.73,112.01) v1(411.73,106.93) v1(411.73,101.85) v1(411.73,91.69) v1(411.73,86.61) v1(411.73,81.53) v1(411.73,76.45) v1(411.73,71.37) v1(411.73,66.29) v1(411.73,61.21) v1(411.73,56.13) v1(411.73,51.05) v1(411.73,45.97) v1(411.73,40.89) v1(411.73,35.81) v1(411.73,30.73) v1(411.73,25.65) v1(411.73,20.57) v1(411.73,15.49) v1(411.73,10.41) v2(205.45,19.31) v2(207.84,21.71) v2(208.24,18.51) v2(208.64,19.71)
